v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 90 -670 120 -670 {lab=GND}
N 90 -620 120 -620 {lab=GND}
N 280 -620 280 -560 {lab=#net1}
N 280 -670 300 -670 {lab=#net2}
N 300 -670 300 -560 {lab=#net2}
N 50 -440 50 -410 {lab=in1}
N 50 -500 100 -500 {lab=in1}
N 170 -260 170 -240 {lab=#net3}
N 170 -460 210 -460 {lab=in2}
N 170 -460 170 -410 {lab=in2}
N 300 -400 300 -370 {lab=GND}
N 370 -500 400 -500 {lab=out1}
N 370 -460 400 -460 {lab=out2}
N 160 -500 210 -500 {lab=#net4}
N 280 -170 280 -140 {lab=GND}
N 280 -400 280 -330 {lab=#net5}
N 280 -270 280 -230 {lab=#net6}
N 180 -670 190 -670 {lab=#net7}
N 180 -620 190 -620 {lab=#net8}
N 250 -620 280 -620 {lab=#net1}
N 250 -670 280 -670 {lab=#net2}
N -840 -470 -840 -450 {lab=VDD}
N -850 -630 -850 -590 {lab=_CLKA}
N -810 -630 -810 -590 {lab=CLKA}
N -810 -440 -810 -410 {lab=CLKA}
N -850 -440 -850 -410 {lab=_CLKA}
N -840 -290 -840 -270 {lab=VDD}
N -810 -250 -810 -230 {lab=CLKA}
N -850 -250 -850 -230 {lab=_CLKA}
N -840 -110 -840 -90 {lab=VDD}
N -810 -70 -810 -50 {lab=CLKA}
N -850 -70 -850 -50 {lab=_CLKA}
N -840 70 -840 90 {lab=VDD}
N -760 -540 -660 -540 {lab=Vout1nA}
N -660 -540 -660 -470 {lab=Vout1nA}
N -660 -470 -610 -470 {lab=Vout1nA}
N -680 -500 -610 -500 {lab=Vout1pA}
N -680 -520 -680 -500 {lab=Vout1pA}
N -760 -520 -680 -520 {lab=Vout1pA}
N -760 -360 -660 -360 {lab=Vout2nA}
N -660 -410 -660 -360 {lab=Vout2nA}
N -660 -410 -610 -410 {lab=Vout2nA}
N -680 -440 -610 -440 {lab=Vout2pA}
N -680 -440 -680 -340 {lab=Vout2pA}
N -760 -340 -680 -340 {lab=Vout2pA}
N -760 -180 -640 -180 {lab=#net9}
N -640 -180 -640 -160 {lab=#net9}
N -640 -160 -610 -160 {lab=#net9}
N -760 -160 -670 -160 {lab=#net10}
N -670 -190 -670 -160 {lab=#net10}
N -670 -190 -610 -190 {lab=#net10}
N -760 0 -650 0 {lab=#net11}
N -650 -100 -650 0 {lab=#net11}
N -650 -100 -610 -100 {lab=#net11}
N -660 -130 -610 -130 {lab=#net12}
N -660 -130 -660 20 {lab=#net12}
N -760 20 -660 20 {lab=#net12}
N -550 -40 -550 -10 {lab=VDD}
N -550 -300 -550 -260 {lab=_CLKB}
N -510 -300 -510 -260 {lab=CLKB}
N -550 -350 -550 -330 {lab=VDD}
N -550 -610 -550 -570 {lab=_CLKB}
N -510 -610 -510 -570 {lab=CLKB}
N -450 -500 -380 -500 {lab=Vout1pB}
N -380 -500 -380 -440 {lab=Vout1pB}
N -380 -440 -340 -440 {lab=Vout1pB}
N -450 -470 -400 -470 {lab=Vout1nB}
N -400 -470 -400 -410 {lab=Vout1nB}
N -400 -410 -340 -410 {lab=Vout1nB}
N -450 -440 -420 -440 {lab=Vout2pB}
N -420 -440 -420 -380 {lab=Vout2pB}
N -420 -380 -340 -380 {lab=Vout2pB}
N -450 -410 -450 -350 {lab=Vout2nB}
N -450 -350 -340 -350 {lab=Vout2nB}
N -450 -320 -450 -190 {lab=Vout3pB}
N -450 -320 -340 -320 {lab=Vout3pB}
N -450 -160 -420 -160 {lab=Vout3nB}
N -420 -290 -420 -160 {lab=Vout3nB}
N -420 -290 -340 -290 {lab=Vout3nB}
N -400 -260 -340 -260 {lab=Vout4pB}
N -400 -260 -400 -130 {lab=Vout4pB}
N -450 -130 -400 -130 {lab=Vout4pB}
N -450 -100 -370 -100 {lab=Vout4nB}
N -370 -230 -370 -100 {lab=Vout4nB}
N -370 -230 -340 -230 {lab=Vout4nB}
N -250 -160 -250 -120 {lab=#net7}
N -250 -560 -250 -500 {lab=_CLKC}
N -210 -560 -210 -500 {lab=CLKC}
N -1080 -520 -890 -520 {lab=Vin1n}
N -940 -540 -890 -540 {lab=Vin1p}
N -1080 -340 -890 -340 {lab=Vin2n}
N -940 -360 -890 -360 {lab=Vin2p}
N -1080 -160 -890 -160 {lab=Vin3n}
N -940 -180 -890 -180 {lab=Vin3p}
N -1080 20 -890 20 {lab=Vin4n}
N -940 0 -890 0 {lab=Vin4p}
N -120 -440 30 -440 {lab=in1}
N 30 -440 30 -400 {lab=in1}
N 30 -400 50 -400 {lab=in1}
N 50 -410 50 -400 {lab=in1}
N -120 -410 -0 -410 {lab=#net3}
N 0 -410 0 -210 {lab=#net3}
N 0 -210 170 -210 {lab=#net3}
N 170 -240 170 -210 {lab=#net3}
N 50 -500 50 -440 {lab=in1}
N 170 -320 170 -260 {lab=#net3}
N -750 -1100 -720 -1100 {lab=CLKA}
N -930 -1100 -900 -1100 {lab=VDD}
N -930 -1080 -900 -1080 {lab=GND}
N -930 -1060 -900 -1060 {lab=#net13}
N -930 -930 -900 -930 {lab=#net14}
N -930 -950 -900 -950 {lab=GND}
N -930 -970 -900 -970 {lab=#net15}
N -930 -830 -900 -830 {lab=#net16}
N -930 -810 -910 -810 {lab=GND}
N -910 -810 -900 -810 {lab=GND}
N -930 -790 -900 -790 {lab=#net17}
N -750 -1080 -720 -1080 {lab=_CLKA}
N -750 -970 -720 -970 {lab=_CLKB}
N -750 -950 -720 -950 {lab=CLKB}
N -750 -830 -720 -830 {lab=CLKC}
N -750 -810 -720 -810 {lab=_CLKC}
N -1090 -790 -930 -790 {lab=#net17}
N -1090 -1060 -930 -1060 {lab=#net13}
N -1090 -930 -930 -930 {lab=#net14}
N -550 -970 -550 -610 {lab=_CLKB}
N -720 -970 -550 -970 {lab=_CLKB}
N -510 -950 -510 -610 {lab=CLKB}
N -720 -950 -510 -950 {lab=CLKB}
N -250 -810 -250 -560 {lab=_CLKC}
N -720 -810 -250 -810 {lab=_CLKC}
N -720 -830 -220 -830 {lab=CLKC}
N -220 -830 -210 -830 {lab=CLKC}
N -210 -830 -210 -560 {lab=CLKC}
N -720 -1080 -710 -1080 {lab=_CLKA}
N -710 -1080 -710 -730 {lab=_CLKA}
N -850 -730 -710 -730 {lab=_CLKA}
N -850 -730 -850 -630 {lab=_CLKA}
N -720 -1100 -690 -1100 {lab=CLKA}
N -690 -1100 -690 -690 {lab=CLKA}
N -810 -690 -690 -690 {lab=CLKA}
N -810 -690 -810 -630 {lab=CLKA}
N 170 -350 170 -320 {lab=#net3}
N -250 -120 -40 -120 {lab=#net7}
N -40 -730 -40 -120 {lab=#net7}
N -40 -730 170 -730 {lab=#net7}
N 190 -730 190 -670 {lab=#net7}
N 170 -730 190 -730 {lab=#net7}
C {title.sym} 200 -80 0 0 {name=l8 author="GenYZ Team"}
C {vsource.sym} 150 -670 1 0 {name=V1 value=3.3 savecurrent=false
L=3u
W=270uu}
C {gnd.sym} 90 -670 1 0 {name=l3 lab=GND}
C {vsource.sym} 150 -620 1 0 {name=V3 value=1.5 savecurrent=false
L=3u
W=270uu}
C {gnd.sym} 90 -620 1 0 {name=l4 lab=GND}
C {lab_wire.sym} 80 -500 0 0 {name=p1 sig_type=std_logic lab=in1
L=3u
W=270uu}
C {lab_wire.sym} 170 -450 2 0 {name=p2 sig_type=std_logic lab=in2}
C {gnd.sym} 300 -370 0 0 {name=l5 lab=GND}
C {noconn.sym} -120 -380 2 0 {name=l7}
C {noconn.sym} 400 -460 2 0 {name=l6}
C {lab_wire.sym} 390 -460 3 0 {name=p3 sig_type=std_logic lab=out2}
C {lab_wire.sym} 390 -500 1 0 {name=p4 sig_type=std_logic lab=out1}
C {devices/code_shown.sym} 530 -320 0 0 {name=MODELS only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/smbb000149.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
"}
C {devices/code_shown.sym} 510 -830 0 0 {name=NGSPICE only_toplevel=true
value="
	* -- AC ANALYSIS ---
	*.ac dec 100 1 1e8
	* -- TRANSIENT --
	.tran 500u 0.5m
.control
	* Ac sweep
	ac
	set gnuplot = 1
	setplot ac1
	display
	setplot
	set color0=white
	* Eksekusi transien
	reset
	run

	* Plot transient
	plot V(in1)-V(in2) 
	plot V(out1)-V(out2)
	plot V(out1)-V(out2) V(in1)-V(in2) 
	*plot db(V(out1)-V(out2)/V(in1)-V(in2))
	*plot ph(V(out1)-V(out2)/V(in1)-V(in2))	

save all

.endc
"}
C {vsource.sym} 280 -200 0 0 {name=V7 value=1 savecurrent=false}
C {gnd.sym} 280 -140 0 0 {name=l9 lab=GND}
C {INA_STAGE_FIXED.sym} 180 -300 0 0 {name=x1}
C {res.sym} 280 -300 2 0 {name=R3
value=150m
footprint=1206
device=resistor
m=1}
C {res.sym} 220 -620 3 0 {name=R4
value=150m
footprint=1206
device=resistor
m=1}
C {res.sym} 220 -670 3 0 {name=R5
value=150m
footprint=1206
device=resistor
m=1}
C {switch_A.sym} -930 -470 0 0 {name=x2}
C {switch_A.sym} -930 -290 0 0 {name=x3}
C {switch_A.sym} -930 -110 0 0 {name=x4}
C {switch_A.sym} -930 70 0 0 {name=x5}
C {switch_C.sym} -230 -380 0 0 {name=x7}
C {vsource.sym} -1030 -540 1 0 {name=Vinp4 value=1.75 savecurrent=false}
C {gnd.sym} -1060 -540 1 0 {name=l10 lab=GND}
C {res.sym} -970 -540 3 0 {name=R6
value=50k
footprint=1206
device=resistor
m=1}
C {vsource.sym} -1170 -520 1 0 {name=Vinn4 value=1.5 savecurrent=false}
C {gnd.sym} -1200 -520 1 0 {name=l11 lab=GND}
C {res.sym} -1110 -520 3 0 {name=R7
value=50k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} -910 -540 1 0 {name=p5 sig_type=std_logic lab=Vin1p}
C {lab_pin.sym} -910 -360 1 0 {name=p6 sig_type=std_logic lab=Vin2p}
C {vsource.sym} -1030 -360 1 0 {name=Vinp5 value=100u savecurrent=false}
C {gnd.sym} -1060 -360 1 0 {name=l12 lab=GND}
C {res.sym} -970 -360 3 0 {name=R8
value=50k
footprint=1206
device=resistor
m=1}
C {vsource.sym} -1170 -340 1 0 {name=Vinn5 value=30u savecurrent=false}
C {gnd.sym} -1200 -340 1 0 {name=l13 lab=GND}
C {res.sym} -1110 -340 3 0 {name=R12
value=50k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} -910 -520 3 0 {name=p7 sig_type=std_logic lab=Vin1n}
C {lab_pin.sym} -910 -340 3 0 {name=p8 sig_type=std_logic lab=Vin2n}
C {vsource.sym} -1030 -180 1 0 {name=Vinp6 value=100u savecurrent=false}
C {gnd.sym} -1060 -180 1 0 {name=l14 lab=GND}
C {res.sym} -970 -180 3 0 {name=R13
value=50k
footprint=1206
device=resistor
m=1}
C {vsource.sym} -1170 -160 1 0 {name=Vinn6 value=40u savecurrent=false}
C {gnd.sym} -1200 -160 1 0 {name=l15 lab=GND}
C {res.sym} -1110 -160 3 0 {name=R14
value=50k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} -910 -180 1 0 {name=p9 sig_type=std_logic lab=Vin3p}
C {lab_pin.sym} -910 0 1 0 {name=p10 sig_type=std_logic lab=Vin4p}
C {vsource.sym} -1030 0 1 0 {name=Vinp7 value=100u savecurrent=false}
C {gnd.sym} -1060 0 1 0 {name=l16 lab=GND}
C {res.sym} -970 0 3 0 {name=R15
value=50k
footprint=1206
device=resistor
m=1}
C {vsource.sym} -1170 20 1 0 {name=Vinn7 value=50u savecurrent=false}
C {gnd.sym} -1200 20 1 0 {name=l17 lab=GND}
C {res.sym} -1110 20 3 0 {name=R16
value=50k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} -920 -160 3 0 {name=p11 sig_type=std_logic lab=Vin3n}
C {lab_pin.sym} -910 20 3 0 {name=p12 sig_type=std_logic lab=Vin4n}
C {noconn.sym} -850 -440 0 0 {name=l26}
C {noconn.sym} -810 -440 0 0 {name=l27}
C {noconn.sym} -850 -250 0 0 {name=l28}
C {noconn.sym} -810 -250 0 0 {name=l29}
C {noconn.sym} -850 -70 0 0 {name=l30}
C {noconn.sym} -810 -70 0 0 {name=l31}
C {noconn.sym} -840 -90 0 0 {name=l32}
C {noconn.sym} -840 90 0 0 {name=l34}
C {noconn.sym} -840 -450 0 0 {name=l36}
C {noconn.sym} -550 -330 0 0 {name=l40}
C {noconn.sym} -550 -300 0 0 {name=l42}
C {noconn.sym} -510 -300 0 0 {name=l43}
C {noconn.sym} -550 -10 0 0 {name=l44}
C {lab_pin.sym} -850 -630 1 0 {name=p15 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} -850 -430 1 0 {name=p16 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} -850 -240 1 0 {name=p17 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} -850 -60 1 0 {name=p18 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} -810 -630 1 0 {name=p19 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} -810 -420 1 0 {name=p20 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} -810 -240 1 0 {name=p21 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} -810 -60 1 0 {name=p22 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} -550 -610 1 0 {name=p23 sig_type=std_logic lab=_CLKB}
C {lab_pin.sym} -550 -280 1 0 {name=p24 sig_type=std_logic lab=_CLKB}
C {lab_pin.sym} -510 -610 1 0 {name=p25 sig_type=std_logic lab=CLKB}
C {lab_pin.sym} -510 -290 1 0 {name=p26 sig_type=std_logic lab=CLKB}
C {lab_pin.sym} -250 -560 1 0 {name=p27 sig_type=std_logic lab=_CLKC}
C {lab_pin.sym} -210 -560 1 0 {name=p28 sig_type=std_logic lab=CLKC}
C {gnd.sym} -210 -160 0 0 {name=l41 lab=GND}
C {gnd.sym} -510 -350 0 0 {name=l47 lab=GND}
C {gnd.sym} -510 -40 0 0 {name=l45 lab=GND}
C {noconn.sym} -840 -270 0 0 {name=l33}
C {gnd.sym} -810 -470 0 0 {name=l35 lab=GND}
C {gnd.sym} -810 -290 0 0 {name=l37 lab=GND}
C {gnd.sym} -810 -110 0 0 {name=l50 lab=GND}
C {gnd.sym} -810 70 0 0 {name=l51 lab=GND}
C {lab_pin.sym} -550 -340 2 0 {name=p30 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -550 -20 2 0 {name=p31 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -840 80 2 0 {name=p32 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -840 -100 2 0 {name=p33 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -840 -280 2 0 {name=p34 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -840 -460 2 0 {name=p35 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -720 -520 2 0 {name=p37 sig_type=std_logic lab=Vout1pA}
C {lab_pin.sym} -710 -540 2 0 {name=p46 sig_type=std_logic lab=Vout1nA}
C {lab_pin.sym} -730 -340 2 0 {name=p47 sig_type=std_logic lab=Vout2pA}
C {lab_pin.sym} -710 -360 2 0 {name=p48 sig_type=std_logic lab=Vout2nA}
C {lab_pin.sym} -410 -500 2 0 {name=p53 sig_type=std_logic lab=Vout1pB}
C {lab_pin.sym} -400 -450 2 0 {name=p54 sig_type=std_logic lab=Vout1nB}
C {lab_pin.sym} -410 -380 2 0 {name=p55 sig_type=std_logic lab=Vout2pB}
C {lab_pin.sym} -450 -350 2 0 {name=p56 sig_type=std_logic lab=Vout2nB}
C {switch_B.sym} -470 -350 0 0 {name=x6}
C {switch_B.sym} -470 -40 0 0 {name=x8}
C {lab_pin.sym} -440 -320 2 0 {name=p38 sig_type=std_logic lab=Vout3pB}
C {lab_pin.sym} -400 -190 2 0 {name=p39 sig_type=std_logic lab=Vout4pB}
C {lab_pin.sym} -420 -260 2 0 {name=p40 sig_type=std_logic lab=Vout3nB}
C {lab_pin.sym} -370 -110 2 0 {name=p41 sig_type=std_logic lab=Vout4nB}
C {gnd.sym} -930 -810 1 0 {name=l1 lab=GND}
C {vsource.sym} -1020 -830 1 0 {name=VDD value=3.3 savecurrent=false}
C {gnd.sym} -1050 -830 1 0 {name=l2 lab=GND}
C {res.sym} -960 -830 3 0 {name=R1
value=150m
footprint=1206
device=resistor
m=1}
C {vsource.sym} -1180 -790 1 0 {name=Vclkin value="PULSE(0 3.3 0 1n 1n 0.5m 1m)" savecurrent=false}
C {gnd.sym} -1210 -790 1 0 {name=l18 lab=GND}
C {res.sym} -1120 -790 3 0 {name=R2
value=50
footprint=1206
device=resistor
m=1}
C {gnd.sym} -930 -1080 1 0 {name=l19 lab=GND}
C {vsource.sym} -1020 -1100 1 0 {name=VDD1 value=3.3 savecurrent=false}
C {gnd.sym} -1050 -1100 1 0 {name=l20 lab=GND}
C {res.sym} -960 -1100 3 0 {name=R9
value=150m
footprint=1206
device=resistor
m=1}
C {vsource.sym} -1180 -1060 1 0 {name=Vclkin1 value="PULSE(0 3.3 0 100n 100n 125u 250u)" savecurrent=false}
C {gnd.sym} -1210 -1060 1 0 {name=l21 lab=GND}
C {res.sym} -1120 -1060 3 0 {name=R10
value=50
footprint=1206
device=resistor
m=1}
C {gnd.sym} -930 -950 1 0 {name=l22 lab=GND}
C {vsource.sym} -1020 -970 1 0 {name=VDD2 value=3.3 savecurrent=false}
C {gnd.sym} -1050 -970 1 0 {name=l23 lab=GND}
C {res.sym} -960 -970 3 0 {name=R11
value=150m
footprint=1206
device=resistor
m=1}
C {vsource.sym} -1180 -930 1 0 {name=Vclkin2 value="PULSE(0 3.3 0 100n 100n 250u 500u)" savecurrent=false}
C {gnd.sym} -1210 -930 1 0 {name=l24 lab=GND}
C {res.sym} -1120 -930 3 0 {name=R17
value=50
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} -920 -1100 1 0 {name=p45 sig_type=std_logic lab=VDD}
C {clk.sym} -750 -1080 0 0 {name=x9}
C {clk.sym} -750 -950 0 0 {name=x10}
C {clk.sym} -750 -810 0 0 {name=x11}
C {noconn.sym} 400 -500 2 0 {name=l25}
C {noconn.sym} -120 -350 2 0 {name=l38}
C {noconn.sym} -120 -320 2 0 {name=l39}
C {noconn.sym} -120 -290 2 0 {name=l48}
C {noconn.sym} -120 -260 2 0 {name=l49}
C {noconn.sym} -120 -230 2 0 {name=l52}
C {vsource.sym} 170 -380 0 0 {name=V2 value=1.5 savecurrent=false}
C {vsource.sym} 130 -500 1 0 {name=V4 value=1.5 savecurrent=false}
