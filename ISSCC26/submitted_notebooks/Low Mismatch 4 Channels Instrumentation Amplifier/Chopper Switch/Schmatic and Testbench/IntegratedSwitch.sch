v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 1390 10 1420 10 {lab=_CLKA}
N 1210 10 1240 10 {lab=VDD}
N 1210 30 1240 30 {lab=GND}
N 1210 50 1240 50 {lab=#net1}
N 1210 180 1240 180 {lab=#net2}
N 1210 160 1240 160 {lab=GND}
N 1210 140 1240 140 {lab=#net3}
N 1210 280 1240 280 {lab=#net4}
N 1210 300 1230 300 {lab=GND}
N 1230 300 1240 300 {lab=GND}
N 1210 320 1240 320 {lab=#net5}
N -30 0 -30 20 {lab=VDD}
N 1390 30 1420 30 {lab=CLKA}
N 1390 140 1420 140 {lab=_CLKB}
N 1390 160 1420 160 {lab=CLKB}
N 1390 280 1420 280 {lab=_CLKC}
N 1390 300 1420 300 {lab=CLKC}
N -40 -160 -40 -120 {lab=_CLKA}
N -0 -160 0 -120 {lab=CLKA}
N -0 30 -0 60 {lab=CLKA}
N -40 30 -40 60 {lab=_CLKA}
N -30 180 -30 200 {lab=VDD}
N 0 220 -0 240 {lab=CLKA}
N -40 220 -40 240 {lab=_CLKA}
N -30 360 -30 380 {lab=VDD}
N 0 400 0 420 {lab=CLKA}
N -40 400 -40 420 {lab=_CLKA}
N -30 540 -30 560 {lab=VDD}
N 50 -70 150 -70 {lab=Vout1nA}
N 150 -70 150 -0 {lab=Vout1nA}
N 150 -0 200 0 {lab=Vout1nA}
N 130 -30 200 -30 {lab=Vout1pA}
N 130 -50 130 -30 {lab=Vout1pA}
N 50 -50 130 -50 {lab=Vout1pA}
N 50 110 150 110 {lab=Vout2nA}
N 150 60 150 110 {lab=Vout2nA}
N 150 60 200 60 {lab=Vout2nA}
N 130 30 200 30 {lab=Vout2pA}
N 130 30 130 130 {lab=Vout2pA}
N 50 130 130 130 {lab=Vout2pA}
N 50 290 170 290 {lab=#net6}
N 170 290 170 310 {lab=#net6}
N 170 310 200 310 {lab=#net6}
N 50 310 140 310 {lab=#net7}
N 140 280 140 310 {lab=#net7}
N 140 280 200 280 {lab=#net7}
N 50 470 160 470 {lab=#net8}
N 160 370 160 470 {lab=#net8}
N 160 370 200 370 {lab=#net8}
N 150 340 200 340 {lab=#net9}
N 150 340 150 490 {lab=#net9}
N 50 490 150 490 {lab=#net9}
N 260 430 260 460 {lab=VDD}
N 260 170 260 210 {lab=_CLKB}
N 300 170 300 210 {lab=CLKB}
N 260 120 260 140 {lab=VDD}
N 260 -140 260 -100 {lab=_CLKB}
N 300 -140 300 -100 {lab=CLKB}
N 360 -30 430 -30 {lab=Vout1pB}
N 430 -30 430 30 {lab=Vout1pB}
N 430 30 470 30 {lab=Vout1pB}
N 360 -0 410 0 {lab=Vout1nB}
N 410 0 410 60 {lab=Vout1nB}
N 410 60 470 60 {lab=Vout1nB}
N 360 30 390 30 {lab=Vout2pB}
N 390 30 390 90 {lab=Vout2pB}
N 390 90 470 90 {lab=Vout2pB}
N 360 60 360 120 {lab=Vout2nB}
N 360 120 470 120 {lab=Vout2nB}
N 360 150 360 280 {lab=#net10}
N 360 150 470 150 {lab=#net10}
N 360 310 390 310 {lab=#net11}
N 390 180 390 310 {lab=#net11}
N 390 180 470 180 {lab=#net11}
N 410 210 470 210 {lab=#net12}
N 410 210 410 340 {lab=#net12}
N 360 340 410 340 {lab=#net12}
N 360 370 440 370 {lab=#net13}
N 440 240 440 370 {lab=#net13}
N 440 240 470 240 {lab=#net13}
N 560 310 560 350 {lab=VDD}
N 560 350 560 360 {lab=VDD}
N 560 -90 560 -30 {lab=_CLKC}
N 600 -90 600 -30 {lab=CLKC}
N -270 -50 -80 -50 {lab=Vin1n}
N -130 -70 -80 -70 {lab=Vin1p}
N -270 130 -80 130 {lab=Vin2n}
N -130 110 -80 110 {lab=Vin2p}
N -270 310 -80 310 {lab=Vin3n}
N -130 290 -80 290 {lab=Vin3p}
N -270 490 -80 490 {lab=Vin4n}
N -130 470 -80 470 {lab=Vin4p}
N 1050 320 1210 320 {lab=#net5}
N 1050 50 1210 50 {lab=#net1}
N 1050 180 1210 180 {lab=#net2}
N 690 30 720 30 {lab=Vout1p}
N 690 60 720 60 {lab=Vout1n}
N 690 90 720 90 {lab=Vout2p}
N 690 120 720 120 {lab=Vout2n}
N 690 150 720 150 {lab=Vout3p}
N 690 180 720 180 {lab=Vout3n}
N 690 210 720 210 {lab=Vout4p}
N 690 240 720 240 {lab=Vout4n}
C {switch_A.sym} -120 0 0 0 {name=x1}
C {switch_A.sym} -120 180 0 0 {name=x2}
C {switch_A.sym} -120 360 0 0 {name=x3}
C {switch_A.sym} -120 540 0 0 {name=x4}
C {switch_C.sym} 580 90 0 0 {name=x7}
C {vsource.sym} -220 -70 1 0 {name=Vinp4 value=1.75 savecurrent=false}
C {gnd.sym} -250 -70 1 0 {name=l1 lab=GND}
C {res.sym} -160 -70 3 0 {name=R1
value=50k
footprint=1206
device=resistor
m=1}
C {vsource.sym} -360 -50 1 0 {name=Vinn4 value=1.55 savecurrent=false}
C {gnd.sym} -390 -50 1 0 {name=l2 lab=GND}
C {res.sym} -300 -50 3 0 {name=R2
value=50k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} -100 -70 1 0 {name=p5 sig_type=std_logic lab=Vin1p}
C {lab_pin.sym} -100 110 1 0 {name=p6 sig_type=std_logic lab=Vin2p}
C {vsource.sym} -220 110 1 0 {name=Vinp5 value=1.85 savecurrent=false}
C {gnd.sym} -250 110 1 0 {name=l3 lab=GND}
C {res.sym} -160 110 3 0 {name=R7
value=50k
footprint=1206
device=resistor
m=1}
C {vsource.sym} -360 130 1 0 {name=Vinn5 value=1.55 savecurrent=false}
C {gnd.sym} -390 130 1 0 {name=l8 lab=GND}
C {res.sym} -300 130 3 0 {name=R12
value=50k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} -100 -50 3 0 {name=p7 sig_type=std_logic lab=Vin1n}
C {lab_pin.sym} -100 130 3 0 {name=p8 sig_type=std_logic lab=Vin2n}
C {vsource.sym} -220 290 1 0 {name=Vinp6 value=1.70 savecurrent=false}
C {gnd.sym} -250 290 1 0 {name=l9 lab=GND}
C {res.sym} -160 290 3 0 {name=R13
value=50k
footprint=1206
device=resistor
m=1}
C {vsource.sym} -360 310 1 0 {name=Vinn6 value=1.60 savecurrent=false}
C {gnd.sym} -390 310 1 0 {name=l10 lab=GND}
C {res.sym} -300 310 3 0 {name=R14
value=50k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} -100 290 1 0 {name=p9 sig_type=std_logic lab=Vin3p}
C {lab_pin.sym} -100 470 1 0 {name=p10 sig_type=std_logic lab=Vin4p}
C {vsource.sym} -220 470 1 0 {name=Vinp7 value=1.95 savecurrent=false}
C {gnd.sym} -250 470 1 0 {name=l11 lab=GND}
C {res.sym} -160 470 3 0 {name=R15
value=50k
footprint=1206
device=resistor
m=1}
C {vsource.sym} -360 490 1 0 {name=Vinn7 value=1.45 savecurrent=false}
C {gnd.sym} -390 490 1 0 {name=l12 lab=GND}
C {res.sym} -300 490 3 0 {name=R16
value=50k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} -110 310 3 0 {name=p11 sig_type=std_logic lab=Vin3n}
C {lab_pin.sym} -100 490 3 0 {name=p12 sig_type=std_logic lab=Vin4n}
C {gnd.sym} 1210 300 1 0 {name=l4 lab=GND}
C {vsource.sym} 1120 280 1 0 {name=VDD value=3.3 savecurrent=false}
C {gnd.sym} 1090 280 1 0 {name=l5 lab=GND}
C {res.sym} 1180 280 3 0 {name=R3
value=150m
footprint=1206
device=resistor
m=1}
C {vsource.sym} 960 320 1 0 {name=Vclkin value="PULSE(0 3.3 0 1n 1n 0.5m 1m)" savecurrent=false}
C {gnd.sym} 930 320 1 0 {name=l6 lab=GND}
C {res.sym} 1020 320 3 0 {name=R4
value=50
footprint=1206
device=resistor
m=1}
C {gnd.sym} 1210 30 1 0 {name=l7 lab=GND}
C {vsource.sym} 1120 10 1 0 {name=VDD1 value=3.3 savecurrent=false}
C {gnd.sym} 1090 10 1 0 {name=l13 lab=GND}
C {res.sym} 1180 10 3 0 {name=R5
value=150m
footprint=1206
device=resistor
m=1}
C {vsource.sym} 960 50 1 0 {name=Vclkin1 value="PULSE(0 3.3 0 100n 100n 125u 250u)" savecurrent=false}
C {gnd.sym} 930 50 1 0 {name=l14 lab=GND}
C {res.sym} 1020 50 3 0 {name=R6
value=50
footprint=1206
device=resistor
m=1}
C {gnd.sym} 1210 160 1 0 {name=l15 lab=GND}
C {vsource.sym} 1120 140 1 0 {name=VDD2 value=3.3 savecurrent=false}
C {gnd.sym} 1090 140 1 0 {name=l16 lab=GND}
C {res.sym} 1180 140 3 0 {name=R8
value=150m
footprint=1206
device=resistor
m=1}
C {vsource.sym} 960 180 1 0 {name=Vclkin2 value="PULSE(0 3.3 0 100n 100n 250u 500u)" savecurrent=false}
C {gnd.sym} 930 180 1 0 {name=l17 lab=GND}
C {res.sym} 1020 180 3 0 {name=R9
value=50
footprint=1206
device=resistor
m=1}
C {noconn.sym} 1420 10 0 0 {name=l18}
C {noconn.sym} 1420 30 0 0 {name=l19}
C {noconn.sym} 1420 140 0 0 {name=l20}
C {noconn.sym} 1420 160 0 0 {name=l21}
C {noconn.sym} 1420 280 0 0 {name=l22}
C {noconn.sym} 1420 300 0 0 {name=l23}
C {lab_pin.sym} 1410 10 1 0 {name=p1 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} 1410 30 3 0 {name=p2 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 1410 140 1 0 {name=p3 sig_type=std_logic lab=_CLKB}
C {lab_pin.sym} 1410 160 3 0 {name=p4 sig_type=std_logic lab=CLKB}
C {lab_pin.sym} 1400 280 1 0 {name=p13 sig_type=std_logic lab=_CLKC}
C {lab_pin.sym} 1400 300 3 0 {name=p14 sig_type=std_logic lab=CLKC}
C {noconn.sym} -40 -160 0 0 {name=l24}
C {noconn.sym} 0 -160 0 0 {name=l25}
C {noconn.sym} -40 30 0 0 {name=l26}
C {noconn.sym} 0 30 0 0 {name=l27}
C {noconn.sym} -40 220 0 0 {name=l28}
C {noconn.sym} 0 220 0 0 {name=l29}
C {noconn.sym} -40 400 0 0 {name=l30}
C {noconn.sym} 0 400 0 0 {name=l31}
C {noconn.sym} -30 380 0 0 {name=l32}
C {noconn.sym} -30 560 0 0 {name=l34}
C {noconn.sym} -30 20 0 0 {name=l36}
C {noconn.sym} 260 -140 0 0 {name=l38}
C {noconn.sym} 300 -140 0 0 {name=l39}
C {noconn.sym} 260 140 0 0 {name=l40}
C {noconn.sym} 260 170 0 0 {name=l42}
C {noconn.sym} 300 170 0 0 {name=l43}
C {noconn.sym} 260 460 0 0 {name=l44}
C {noconn.sym} 560 360 0 0 {name=l46}
C {noconn.sym} 560 -90 0 0 {name=l48}
C {noconn.sym} 600 -90 0 0 {name=l49}
C {lab_pin.sym} -40 -150 1 0 {name=p15 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} -40 40 1 0 {name=p16 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} -40 230 1 0 {name=p17 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} -40 410 1 0 {name=p18 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} 0 -150 1 0 {name=p19 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 0 50 1 0 {name=p20 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 0 230 1 0 {name=p21 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 0 410 1 0 {name=p22 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 260 -130 1 0 {name=p23 sig_type=std_logic lab=_CLKB}
C {lab_pin.sym} 260 190 1 0 {name=p24 sig_type=std_logic lab=_CLKB}
C {lab_pin.sym} 300 -130 1 0 {name=p25 sig_type=std_logic lab=CLKB}
C {lab_pin.sym} 300 180 1 0 {name=p26 sig_type=std_logic lab=CLKB}
C {lab_pin.sym} 560 -70 1 0 {name=p27 sig_type=std_logic lab=_CLKC}
C {lab_pin.sym} 600 -60 1 0 {name=p28 sig_type=std_logic lab=CLKC}
C {gnd.sym} 600 310 0 0 {name=l41 lab=GND}
C {gnd.sym} 300 120 0 0 {name=l47 lab=GND}
C {gnd.sym} 300 430 0 0 {name=l45 lab=GND}
C {noconn.sym} -30 200 0 0 {name=l33}
C {gnd.sym} 0 0 0 0 {name=l35 lab=GND}
C {gnd.sym} 0 180 0 0 {name=l37 lab=GND}
C {gnd.sym} 0 360 0 0 {name=l50 lab=GND}
C {gnd.sym} 0 540 0 0 {name=l51 lab=GND}
C {lab_pin.sym} 560 340 2 0 {name=p29 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 260 130 2 0 {name=p30 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 260 450 2 0 {name=p31 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -30 550 2 0 {name=p32 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -30 370 2 0 {name=p33 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -30 190 2 0 {name=p34 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -30 10 2 0 {name=p35 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1220 10 1 0 {name=p36 sig_type=std_logic lab=VDD}
C {devices/code_shown.sym} 910 -260 0 0 {name=MODELS only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
"}
C {devices/code_shown.sym} 640 -380 0 0 {name=NGSPICE only_toplevel=true
value="
.tran 500u 4m
.control
run
plot v(Vout1pA)-v(Vout1nA)
plot v(Vout1pB)-v(Vout1nB)
*plot v(Vout1nB)-v(Vout2nB)
*plot v(Vout2pA)-v(Vout2nA)
plot v(Vout1p)-v(Vout1n)
*plot v(Vout2p)-v(Vout2n)
*plot v(Vout3p)-v(Vout3n)
*plot v(Vout4p)-v(Vout4n)
.endc
"}
C {lab_pin.sym} 710 30 2 0 {name=p38 sig_type=std_logic lab=Vout1p}
C {lab_pin.sym} 710 60 2 0 {name=p39 sig_type=std_logic lab=Vout1n}
C {noconn.sym} 720 30 0 0 {name=l53
lab=Vout1p}
C {noconn.sym} 720 60 0 0 {name=l54}
C {lab_pin.sym} 710 90 2 0 {name=p40 sig_type=std_logic lab=Vout2p}
C {lab_pin.sym} 710 120 2 0 {name=p41 sig_type=std_logic lab=Vout2n}
C {noconn.sym} 720 90 0 0 {name=l55
lab=Vout2p}
C {noconn.sym} 720 120 0 0 {name=l56
lab=Vout2p}
C {lab_pin.sym} 710 150 2 0 {name=p42 sig_type=std_logic lab=Vout3p}
C {noconn.sym} 720 150 0 0 {name=l57
lab=Vout1p}
C {noconn.sym} 720 180 0 0 {name=l58}
C {lab_pin.sym} 710 210 2 0 {name=p43 sig_type=std_logic lab=Vout4p}
C {noconn.sym} 720 210 0 0 {name=l59
lab=Vout2p}
C {noconn.sym} 720 240 0 0 {name=l60
lab=Vout2p}
C {lab_pin.sym} 710 180 2 0 {name=p44 sig_type=std_logic lab=Vout3n}
C {lab_pin.sym} 710 240 2 0 {name=p45 sig_type=std_logic lab=Vout4n}
C {clk.sym} 1390 30 0 0 {name=x8}
C {clk.sym} 1390 160 0 0 {name=x9}
C {clk.sym} 1390 300 0 0 {name=x10}
C {lab_pin.sym} 90 -50 2 0 {name=p37 sig_type=std_logic lab=Vout1pA}
C {lab_pin.sym} 100 -70 2 0 {name=p46 sig_type=std_logic lab=Vout1nA}
C {lab_pin.sym} 80 130 2 0 {name=p47 sig_type=std_logic lab=Vout2pA}
C {lab_pin.sym} 100 110 2 0 {name=p48 sig_type=std_logic lab=Vout2nA}
C {lab_pin.sym} 400 -30 2 0 {name=p53 sig_type=std_logic lab=Vout1pB}
C {lab_pin.sym} 410 20 2 0 {name=p54 sig_type=std_logic lab=Vout1nB}
C {lab_pin.sym} 400 90 2 0 {name=p55 sig_type=std_logic lab=Vout2pB}
C {lab_pin.sym} 360 120 2 0 {name=p56 sig_type=std_logic lab=Vout2nB}
C {switch_B.sym} 340 120 0 0 {name=x5}
C {switch_B.sym} 340 430 0 0 {name=x6}
