v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 1810 -520 1840 -520 {lab=_CLKA}
N 1630 -520 1660 -520 {lab=VDD}
N 1630 -500 1660 -500 {lab=GND}
N 1630 -480 1660 -480 {lab=#net1}
N 1630 -350 1660 -350 {lab=#net2}
N 1630 -370 1660 -370 {lab=GND}
N 1630 -390 1660 -390 {lab=#net3}
N 1630 -250 1660 -250 {lab=#net4}
N 1630 -230 1650 -230 {lab=GND}
N 1650 -230 1660 -230 {lab=GND}
N 1630 -210 1660 -210 {lab=#net5}
N 490 -1000 490 -980 {lab=VDD}
N 1810 -500 1840 -500 {lab=CLKA}
N 1810 -390 1840 -390 {lab=_CLKB}
N 1810 -370 1840 -370 {lab=CLKB}
N 1810 -250 1840 -250 {lab=_CLKC}
N 1810 -230 1840 -230 {lab=CLKC}
N 480 -1160 480 -1120 {lab=CLKA}
N 520 -1160 520 -1120 {lab=_CLKA}
N 520 -970 520 -940 {lab=_CLKA}
N 480 -970 480 -940 {lab=CLKA}
N 490 -820 490 -800 {lab=VDD}
N 520 -780 520 -760 {lab=_CLKA}
N 480 -780 480 -760 {lab=CLKA}
N 490 -640 490 -620 {lab=VDD}
N 520 -600 520 -580 {lab=_CLKA}
N 480 -600 480 -580 {lab=CLKA}
N 490 -460 490 -440 {lab=VDD}
N 570 -1070 670 -1070 {lab=Vout1nA}
N 670 -1070 670 -1000 {lab=Vout1nA}
N 670 -1000 720 -1000 {lab=Vout1nA}
N 650 -1030 720 -1030 {lab=Vout1pA}
N 650 -1050 650 -1030 {lab=Vout1pA}
N 570 -1050 650 -1050 {lab=Vout1pA}
N 570 -890 670 -890 {lab=Vout2nA}
N 670 -940 670 -890 {lab=Vout2nA}
N 670 -940 720 -940 {lab=Vout2nA}
N 650 -970 720 -970 {lab=Vout2pA}
N 650 -970 650 -870 {lab=Vout2pA}
N 570 -870 650 -870 {lab=Vout2pA}
N 570 -710 690 -710 {lab=#net6}
N 690 -710 690 -690 {lab=#net6}
N 690 -690 720 -690 {lab=#net6}
N 570 -690 660 -690 {lab=#net7}
N 660 -720 660 -690 {lab=#net7}
N 660 -720 720 -720 {lab=#net7}
N 570 -530 680 -530 {lab=#net8}
N 680 -630 680 -530 {lab=#net8}
N 680 -630 720 -630 {lab=#net8}
N 670 -660 720 -660 {lab=#net9}
N 670 -660 670 -510 {lab=#net9}
N 570 -510 670 -510 {lab=#net9}
N 780 -570 780 -540 {lab=VDD}
N 780 -830 780 -790 {lab=_CLKB}
N 820 -830 820 -790 {lab=CLKB}
N 780 -880 780 -860 {lab=VDD}
N 780 -1140 780 -1100 {lab=_CLKB}
N 820 -1140 820 -1100 {lab=CLKB}
N 880 -1030 950 -1030 {lab=Vout1pB}
N 950 -1030 950 -970 {lab=Vout1pB}
N 950 -970 990 -970 {lab=Vout1pB}
N 880 -1000 930 -1000 {lab=Vout1nB}
N 930 -1000 930 -940 {lab=Vout1nB}
N 930 -940 990 -940 {lab=Vout1nB}
N 880 -970 910 -970 {lab=Vout2pB}
N 910 -970 910 -910 {lab=Vout2pB}
N 910 -910 990 -910 {lab=Vout2pB}
N 880 -940 880 -880 {lab=Vout2nB}
N 880 -880 990 -880 {lab=Vout2nB}
N 880 -850 880 -720 {lab=Vout3pB}
N 880 -850 990 -850 {lab=Vout3pB}
N 880 -690 910 -690 {lab=Vout3nB}
N 910 -820 910 -690 {lab=Vout3nB}
N 910 -820 990 -820 {lab=Vout3nB}
N 930 -790 990 -790 {lab=Vout4pB}
N 930 -790 930 -660 {lab=Vout4pB}
N 880 -660 930 -660 {lab=Vout4pB}
N 880 -630 960 -630 {lab=Vout4nB}
N 960 -760 960 -630 {lab=Vout4nB}
N 960 -760 990 -760 {lab=Vout4nB}
N 1080 -690 1080 -650 {lab=VDD}
N 1080 -650 1080 -640 {lab=VDD}
N 1080 -1090 1080 -1030 {lab=_CLKC}
N 1120 -1090 1120 -1030 {lab=CLKC}
N 250 -1050 440 -1050 {lab=Vin1n}
N 390 -1070 440 -1070 {lab=Vin1p}
N 250 -870 440 -870 {lab=Vin2n}
N 390 -890 440 -890 {lab=Vin2p}
N 250 -690 440 -690 {lab=Vin3n}
N 390 -710 440 -710 {lab=Vin3p}
N 250 -510 440 -510 {lab=Vin4n}
N 390 -530 440 -530 {lab=Vin4p}
N 1470 -210 1630 -210 {lab=#net5}
N 1470 -480 1630 -480 {lab=#net1}
N 1470 -350 1630 -350 {lab=#net2}
N 2460 -990 2460 -970 {lab=VDD}
N 2450 -1150 2450 -1110 {lab=_CLKA}
N 2490 -1150 2490 -1110 {lab=CLKA}
N 2490 -960 2490 -930 {lab=CLKA}
N 2450 -960 2450 -930 {lab=_CLKA}
N 2460 -810 2460 -790 {lab=VDD}
N 2490 -770 2490 -750 {lab=CLKA}
N 2450 -770 2450 -750 {lab=_CLKA}
N 2460 -630 2460 -610 {lab=VDD}
N 2490 -590 2490 -570 {lab=CLKA}
N 2450 -590 2450 -570 {lab=_CLKA}
N 2460 -450 2460 -430 {lab=VDD}
N 2150 -550 2150 -520 {lab=VDD}
N 2150 -810 2150 -770 {lab=_CLKB}
N 2190 -810 2190 -770 {lab=CLKB}
N 2150 -860 2150 -840 {lab=VDD}
N 2150 -1120 2150 -1080 {lab=_CLKB}
N 2190 -1120 2190 -1080 {lab=CLKB}
N 1800 -700 1800 -660 {lab=VDD}
N 1800 -660 1800 -650 {lab=VDD}
N 1800 -1100 1800 -1040 {lab=_CLKC}
N 1840 -1100 1840 -1040 {lab=CLKC}
N 2540 -1060 2570 -1060 {lab=#net10}
N 2540 -880 2570 -880 {lab=#net11}
N 2540 -860 2570 -860 {lab=#net12}
N 2540 -700 2570 -700 {lab=#net13}
N 2540 -680 2570 -680 {lab=#net14}
N 2540 -520 2570 -520 {lab=#net15}
N 2540 -500 2570 -500 {lab=#net16}
N 1930 -980 1960 -980 {lab=Vout1pB2}
N 1960 -1010 1960 -980 {lab=Vout1pB2}
N 1960 -1010 2090 -1010 {lab=Vout1pB2}
N 2000 -980 2090 -980 {lab=Vout1nB2}
N 2000 -980 2000 -950 {lab=Vout1nB2}
N 1930 -950 2000 -950 {lab=Vout1nB2}
N 1930 -920 2020 -920 {lab=#net17}
N 2020 -950 2020 -920 {lab=#net17}
N 2020 -950 2090 -950 {lab=#net17}
N 1930 -890 2040 -890 {lab=#net18}
N 2040 -920 2040 -890 {lab=#net18}
N 2040 -920 2090 -920 {lab=#net18}
N 1930 -860 2040 -860 {lab=#net19}
N 2040 -860 2040 -700 {lab=#net19}
N 2040 -700 2090 -700 {lab=#net19}
N 1930 -830 2020 -830 {lab=#net20}
N 2020 -830 2020 -670 {lab=#net20}
N 2020 -670 2090 -670 {lab=#net20}
N 1930 -800 1990 -800 {lab=#net21}
N 1990 -800 1990 -640 {lab=#net21}
N 1990 -640 2090 -640 {lab=#net21}
N 1930 -770 1970 -770 {lab=#net22}
N 1970 -770 1970 -610 {lab=#net22}
N 1970 -610 2090 -610 {lab=#net22}
N 2250 -1010 2290 -1010 {lab=Vout1pA2}
N 2290 -1060 2290 -1010 {lab=Vout1pA2}
N 2290 -1060 2410 -1060 {lab=Vout1pA2}
N 2250 -980 2320 -980 {lab=Vout1nA2}
N 2320 -1040 2320 -980 {lab=Vout1nA2}
N 2320 -1040 2410 -1040 {lab=Vout1nA2}
N 2250 -950 2320 -950 {lab=#net23}
N 2320 -950 2320 -880 {lab=#net23}
N 2320 -880 2410 -880 {lab=#net23}
N 2250 -920 2290 -920 {lab=#net24}
N 2290 -920 2290 -860 {lab=#net24}
N 2290 -860 2410 -860 {lab=#net24}
N 2250 -700 2410 -700 {lab=#net25}
N 2250 -670 2380 -670 {lab=#net26}
N 2380 -680 2380 -670 {lab=#net26}
N 2380 -680 2410 -680 {lab=#net26}
N 2250 -640 2380 -640 {lab=#net27}
N 2380 -640 2380 -520 {lab=#net27}
N 2380 -520 2410 -520 {lab=#net27}
N 2250 -610 2340 -610 {lab=#net28}
N 2340 -610 2340 -510 {lab=#net28}
N 2340 -510 2340 -500 {lab=#net28}
N 2340 -500 2410 -500 {lab=#net28}
N 1210 -970 1250 -970 {lab=#net29}
N 1210 -940 1270 -940 {lab=#net30}
N 1210 -910 1300 -910 {lab=#net31}
N 1210 -880 1310 -880 {lab=#net32}
N 1210 -850 1310 -850 {lab=#net33}
N 1210 -820 1290 -820 {lab=#net34}
N 1210 -790 1260 -790 {lab=#net35}
N 1210 -760 1230 -760 {lab=#net36}
N 1680 -980 1710 -980 {lab=#net37}
N 1650 -950 1710 -950 {lab=#net38}
N 1630 -920 1710 -920 {lab=#net39}
N 1600 -890 1710 -890 {lab=#net40}
N 1630 -860 1710 -860 {lab=#net41}
N 1650 -830 1710 -830 {lab=#net42}
N 1670 -800 1710 -800 {lab=#net43}
N 1700 -770 1710 -770 {lab=#net44}
N 1050 -500 1080 -500 {lab=GND}
N 1050 -450 1080 -450 {lab=GND}
N 1140 -500 1150 -500 {lab=#net45}
N 1140 -450 1150 -450 {lab=#net46}
N 1210 -450 1230 -450 {lab=VDD}
N 1210 -500 1230 -500 {lab=VBIAS}
N 1050 -570 1080 -570 {lab=GND}
N 1140 -570 1180 -570 {lab=#net47}
N 1240 -570 1260 -570 {lab=VCM}
N 1250 -970 1370 -970 {lab=#net29}
N 1370 -970 1370 -940 {lab=#net29}
N 1370 -940 1400 -940 {lab=#net29}
N 1270 -940 1350 -940 {lab=#net30}
N 1350 -940 1350 -920 {lab=#net30}
N 1350 -920 1400 -920 {lab=#net30}
N 1300 -910 1340 -910 {lab=#net31}
N 1340 -910 1340 -900 {lab=#net31}
N 1340 -900 1400 -900 {lab=#net31}
N 1310 -880 1400 -880 {lab=#net32}
N 1310 -850 1340 -850 {lab=#net33}
N 1340 -860 1340 -850 {lab=#net33}
N 1340 -860 1400 -860 {lab=#net33}
N 1290 -820 1350 -820 {lab=#net34}
N 1350 -840 1350 -820 {lab=#net34}
N 1350 -840 1400 -840 {lab=#net34}
N 1260 -790 1370 -790 {lab=#net35}
N 1370 -820 1370 -790 {lab=#net35}
N 1370 -820 1400 -820 {lab=#net35}
N 1230 -760 1390 -760 {lab=#net36}
N 1390 -800 1390 -760 {lab=#net36}
N 1390 -800 1400 -800 {lab=#net36}
N 1510 -800 1540 -800 {lab=#net44}
N 1540 -800 1540 -770 {lab=#net44}
N 1540 -770 1700 -770 {lab=#net44}
N 1560 -800 1670 -800 {lab=#net43}
N 1560 -820 1560 -800 {lab=#net43}
N 1510 -820 1560 -820 {lab=#net43}
N 1570 -830 1650 -830 {lab=#net42}
N 1570 -840 1570 -830 {lab=#net42}
N 1510 -840 1570 -840 {lab=#net42}
N 1510 -860 1630 -860 {lab=#net41}
N 1570 -890 1600 -890 {lab=#net40}
N 1570 -890 1570 -880 {lab=#net40}
N 1510 -880 1570 -880 {lab=#net40}
N 1560 -920 1630 -920 {lab=#net39}
N 1560 -920 1560 -900 {lab=#net39}
N 1510 -900 1560 -900 {lab=#net39}
N 1540 -950 1650 -950 {lab=#net38}
N 1540 -950 1540 -920 {lab=#net38}
N 1510 -920 1540 -920 {lab=#net38}
N 1530 -980 1680 -980 {lab=#net37}
N 1530 -980 1530 -940 {lab=#net37}
N 1510 -940 1530 -940 {lab=#net37}
N 1440 -1040 1440 -1000 {lab=VDD}
N 1440 -1050 1440 -1040 {lab=VDD}
N 1460 -1040 1460 -1000 {lab=VBIAS}
N 1460 -1050 1460 -1040 {lab=VBIAS}
N 1440 -730 1440 -690 {lab=VCM}
N 1440 -690 1440 -680 {lab=VCM}
N 1460 -730 1460 -690 {lab=GND}
N 1460 -690 1460 -680 {lab=GND}
N 2570 -1060 2710 -1060 {lab=#net10}
N 2540 -1040 2710 -1040 {lab=#net48}
N 2570 -880 2710 -880 {lab=#net11}
N 2570 -860 2710 -860 {lab=#net12}
N 2570 -520 2710 -520 {lab=#net15}
N 2570 -500 2710 -500 {lab=#net16}
N 2570 -700 2710 -700 {lab=#net13}
N 2570 -680 2710 -680 {lab=#net14}
N 2210 -370 2240 -370 {lab=VDD}
N 2220 -350 2240 -350 {lab=GND}
N 2360 -380 2650 -380 {lab=#net49}
N 2650 -420 2650 -380 {lab=#net49}
N 2650 -420 2710 -420 {lab=#net49}
N 2360 -360 2640 -360 {lab=#net50}
N 2640 -480 2640 -360 {lab=#net50}
N 2640 -480 2710 -480 {lab=#net50}
N 2360 -340 2660 -340 {lab=#net51}
N 2660 -440 2660 -340 {lab=#net51}
N 2660 -440 2710 -440 {lab=#net51}
N 2360 -320 2670 -320 {lab=#net52}
N 2670 -460 2670 -320 {lab=#net52}
N 2670 -460 2710 -460 {lab=#net52}
N 2640 -660 2640 -480 {lab=#net50}
N 2640 -660 2710 -660 {lab=#net50}
N 2640 -840 2640 -660 {lab=#net50}
N 2640 -840 2710 -840 {lab=#net50}
N 2640 -1020 2640 -840 {lab=#net50}
N 2640 -1020 2710 -1020 {lab=#net50}
N 2670 -640 2670 -460 {lab=#net52}
N 2670 -640 2710 -640 {lab=#net52}
N 2670 -820 2670 -640 {lab=#net52}
N 2670 -820 2710 -820 {lab=#net52}
N 2670 -1000 2670 -820 {lab=#net52}
N 2670 -1000 2710 -1000 {lab=#net52}
N 2660 -620 2660 -440 {lab=#net51}
N 2660 -620 2710 -620 {lab=#net51}
N 2660 -800 2660 -620 {lab=#net51}
N 2660 -800 2710 -800 {lab=#net51}
N 2660 -980 2660 -800 {lab=#net51}
N 2660 -980 2710 -980 {lab=#net51}
N 2650 -960 2710 -960 {lab=#net49}
N 2650 -960 2650 -420 {lab=#net49}
N 2650 -600 2710 -600 {lab=#net49}
N 2650 -780 2710 -780 {lab=#net49}
N 2910 -1020 2950 -1020 {lab=OUTCH1PFIN}
N 2910 -1000 2950 -1000 {lab=OUTCH1NFIN}
N 2910 -840 2950 -840 {lab=OUTCH2PFIN}
N 2910 -820 2950 -820 {lab=OUTCH2NFIN}
N 2910 -660 2950 -660 {lab=OUTCH3PFIN}
N 2910 -640 2950 -640 {lab=OUTCH3NFIN}
N 2910 -480 2950 -480 {lab=OUTCH4PFIN}
N 2910 -460 2950 -460 {lab=OUTCH4NFIN}
N 2880 -1020 2910 -1020 {lab=OUTCH1PFIN}
N 2880 -1000 2910 -1000 {lab=OUTCH1NFIN}
N 2880 -840 2910 -840 {lab=OUTCH2PFIN}
N 2880 -820 2910 -820 {lab=OUTCH2NFIN}
N 2880 -660 2910 -660 {lab=OUTCH3PFIN}
N 2880 -640 2910 -640 {lab=OUTCH3NFIN}
N 2880 -480 2910 -480 {lab=OUTCH4PFIN}
N 2880 -460 2910 -460 {lab=OUTCH4NFIN}
N 2780 -1130 2780 -1090 {lab=VDD}
N 2780 -1140 2780 -1130 {lab=VDD}
N 2740 -910 2780 -910 {lab=VDD}
N 2730 -910 2740 -910 {lab=VDD}
N 2740 -730 2780 -730 {lab=VDD}
N 2730 -730 2740 -730 {lab=VDD}
N 2740 -550 2780 -550 {lab=VDD}
N 2730 -550 2740 -550 {lab=VDD}
N 2710 -1060 2730 -1060 {lab=#net10}
N 2710 -1040 2730 -1040 {lab=#net48}
N 2710 -1020 2730 -1020 {lab=#net50}
N 2710 -1000 2730 -1000 {lab=#net52}
N 2710 -980 2730 -980 {lab=#net51}
N 2710 -960 2730 -960 {lab=#net49}
N 2710 -880 2730 -880 {lab=#net11}
N 2710 -860 2730 -860 {lab=#net12}
N 2710 -840 2730 -840 {lab=#net50}
N 2710 -820 2730 -820 {lab=#net52}
N 2710 -800 2730 -800 {lab=#net51}
N 2710 -780 2730 -780 {lab=#net49}
N 2710 -700 2730 -700 {lab=#net13}
N 2710 -680 2730 -680 {lab=#net14}
N 2710 -660 2730 -660 {lab=#net50}
N 2710 -640 2730 -640 {lab=#net52}
N 2710 -620 2730 -620 {lab=#net51}
N 2710 -600 2730 -600 {lab=#net49}
N 2710 -520 2730 -520 {lab=#net15}
N 2710 -500 2730 -500 {lab=#net16}
N 2710 -480 2730 -480 {lab=#net50}
N 2710 -460 2730 -460 {lab=#net52}
N 2710 -440 2730 -440 {lab=#net51}
N 2710 -420 2730 -420 {lab=#net49}
N 2860 -480 2880 -480 {lab=OUTCH4PFIN}
N 2860 -460 2880 -460 {lab=OUTCH4NFIN}
N 2780 -550 2780 -530 {lab=VDD}
N 2800 -550 2800 -530 {lab=GND}
N 2780 -730 2780 -710 {lab=VDD}
N 2860 -640 2880 -640 {lab=OUTCH3NFIN}
N 2860 -660 2880 -660 {lab=OUTCH3PFIN}
N 2800 -730 2800 -710 {lab=GND}
N 2860 -820 2880 -820 {lab=OUTCH2NFIN}
N 2860 -840 2880 -840 {lab=OUTCH2PFIN}
N 2800 -910 2800 -890 {lab=GND}
N 2780 -910 2780 -890 {lab=VDD}
N 2780 -1090 2780 -1070 {lab=VDD}
N 2800 -1090 2800 -1070 {lab=GND}
N 2860 -1020 2880 -1020 {lab=OUTCH1PFIN}
N 2860 -1000 2880 -1000 {lab=OUTCH1NFIN}
N 1530 -480 1530 -440 {lab=#net1}
N 1530 -440 2090 -440 {lab=#net1}
N 2090 -440 2090 -330 {lab=#net1}
N 2090 -330 2240 -330 {lab=#net1}
N 140 -1050 190 -1050 {lab=#net53}
N 140 -870 190 -870 {lab=#net54}
N 140 -690 190 -690 {lab=#net55}
N 140 -510 190 -510 {lab=#net56}
N 170 -1070 260 -1070 {lab=#net53}
N 170 -1070 170 -1050 {lab=#net53}
N 260 -1070 270 -1070 {lab=#net53}
N 170 -890 270 -890 {lab=#net54}
N 170 -890 170 -870 {lab=#net54}
N 170 -710 270 -710 {lab=#net55}
N 170 -710 170 -690 {lab=#net55}
N 170 -530 270 -530 {lab=#net56}
N 170 -530 170 -510 {lab=#net56}
N 310 -1070 330 -1070 {lab=#net57}
N 310 -890 330 -890 {lab=#net58}
N 310 -710 320 -710 {lab=#net59}
N 320 -710 330 -710 {lab=#net59}
N 310 -530 330 -530 {lab=#net60}
C {vsource.sym} 280 -1070 1 0 {name=Vinp4 value="DC 1.5 PWL(0 -0.5u 0.008 5.85u 0.016 5.06u 0.024 -4.9u 0.032 -4.6u 0.04 6.71u 0.048 11.2u 0.056 -1.3u 0.064 -10.4u 0.072 -27.5u 0.08 -24.0u 0.088 -22.5u 0.096 -16.1u 0.104 -12.5u 0.112 -16.1u 0.12 -12.5u 0.128 -7.8u 0.136 -12.6u 0.144 -0.9u 0.152 20.7u 0.16 20.7u 0.168 34.7u 0.176 23.7u 0.184 20.7u 0.192 23.7u 0.2 20.7u 0.208 35.3u 0.216 24.6u 0.224 8.00u 0.232 8u 0.24 6.43u 0.248 -0.2u 0.256 -4.5u 0.264 -1.7u 0.272 -1.6u 0.28 -6.5u 0.288 -11.6u 0.296 -14.5u 0.304 -6.3u 0.312 -14.5u 0.32 -6.3u 0.328 -0.8u 0.336 6.53u 0.344 3.69u 0.352 -12.4u 0.36 -17.6u 0.368 -10.4u 0.376 -9.5u 0.384 -6.9u 0.392 -9.5u 0.4 -6.9u)" savecurrent=false}
C {res.sym} 360 -1070 3 0 {name=R1
value=50k
footprint=1206
device=resistor
m=1}
C {vsource.sym} 110 -1050 1 0 {name=Vinn4 value="1.0" savecurrent=false}
C {gnd.sym} 80 -1050 1 0 {name=l2 lab=GND}
C {res.sym} 220 -1050 3 0 {name=R2
value=50k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} 420 -1070 1 0 {name=p5 sig_type=std_logic lab=Vin1p}
C {lab_pin.sym} 420 -890 1 0 {name=p6 sig_type=std_logic lab=Vin2p}
C {vsource.sym} 280 -890 1 0 {name=Vinp5 value="DC 1.5 PWL(0 1.30u 0.008 3.10u 0.016 0.21u 0.024 -14.u 0.032 -8.9u 0.04 2.00u 0.048 10.0u 0.056 -0.3u 0.064 -27.9u 0.072 -36.3u 0.08 -34.7u 0.088 -41.3u 0.096 -27.6u 0.104 -16.1u 0.112 -27.6u 0.12 -16.1u 0.128 -5.7u 0.136 -2.6u 0.144 9.37u 0.152 36.5u 0.16 48.6u 0.168 50.1u 0.176 32.8u 0.184 30.5u 0.192 32.8u 0.2 30.5u 0.208 32.3u 0.216 20.9u 0.224 18.7u 0.232 18.7u 0.24 15.3u 0.248 3.39u 0.256 3.14u 0.264 1.34u 0.272 -2.8u 0.28 -9.9u 0.288 -17.0u 0.296 -20.0u 0.304 -17.3u 0.312 -20.0u 0.32 -17.3u 0.328 -2.6u 0.336 -4.5u 0.344 -6.4u 0.352 -17.3u 0.36 -35.2u 0.368 -32.8u 0.376 -32.1u 0.384 -34.7u 0.392 -32.1u 0.4 -34.7u)" savecurrent=false}
C {res.sym} 360 -890 3 0 {name=R7
value=50k
footprint=1206
device=resistor
m=1}
C {vsource.sym} 110 -870 1 0 {name=Vinn5 value="1.0" savecurrent=false}
C {gnd.sym} 80 -870 1 0 {name=l8 lab=GND}
C {res.sym} 220 -870 3 0 {name=R12
value=50k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} 420 -1050 3 0 {name=p7 sig_type=std_logic lab=Vin1n}
C {lab_pin.sym} 420 -870 3 0 {name=p8 sig_type=std_logic lab=Vin2n}
C {vsource.sym} 280 -710 1 0 {name=Vinp6 value="DC 1.5 PWL(0 -1.2u 0.008 2.51u 0.016 1.86u 0.024 -9.7u 0.032 -5.4u 0.04 -0.8u 0.048 5.06u 0.056 2.51u 0.064 -15.4u 0.072 -19.0u 0.08 -18.4u 0.088 -25.4u 0.096 -17.7u 0.104 -11.4u 0.112 17.7u 0.12 -11.4u 0.128 -5.98u 0.136 0.34u 0.144 5.98u 0.152 19.3u 0.16 30.2u 0.168 29.2u 0.176 13.7u 0.184 17.8u 0.192 13.7u 0.2 17.8u 0.208 15.7u 0.216 8.20u 0.224 13.4u 0.232 13.4u 0.24 14.7u 0.248 5.86u 0.256 1.73u 0.264 4.34u 0.272 -3.7u 0.28 -8.3u 0.288 -13.u 0.296 -15.u 0.304 -9.2u 0.312 -15.4u 0.32 -9.2u 0.328 1.98u 0.336 -2.9u 0.344 -2.6u 0.352 -9.7u 0.36 -27.4u 0.368 -29.0u 0.376 -23.9u 0.384 -28.1u 0.392 -23.9u 0.4 -28.1u)" savecurrent=false}
C {res.sym} 360 -710 3 0 {name=R13
value=50k
footprint=1206
device=resistor
m=1}
C {vsource.sym} 110 -690 1 0 {name=Vinn6 value="1.0" savecurrent=false}
C {gnd.sym} 80 -690 1 0 {name=l10 lab=GND}
C {res.sym} 220 -690 3 0 {name=R14
value=50k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} 420 -710 1 0 {name=p9 sig_type=std_logic lab=Vin3p}
C {lab_pin.sym} 420 -530 1 0 {name=p10 sig_type=std_logic lab=Vin4p}
C {vsource.sym} 280 -530 1 0 {name=Vinp7 value="DC 1.5 PWL(0 -5.2u 0.008 -2.1u 0.016 4.16u 0.024 -7.5u 0.032 -5.6u 0.04 -1.2u 0.048 4.29u 0.056 5.27u 0.064 -12.0u 0.072 -16.4u 0.08 -14.9u 0.088 -22.7u 0.096 -11.1u 0.104 -2.1u 0.112 -11.1u 0.12 -2.1u 0.128 -1.2u 0.136 8.03u 0.144 7.09u 0.152 14.1u 0.16 23.2u 0.168 20.9u 0.176 11.2u 0.184 12.6u 0.192 11.2u 0.2 12.6u 0.208 7.04u 0.216 -2.2u 0.224 8.14u 0.232 8.14u 0.24 13.9u 0.248 0.46u 0.256 0.23u 0.264 4.14u 0.272 -3.7u 0.28 -5.4u 0.288 -10.1u 0.296 -10.5u 0.304 -5.9u 0.312 -10.5u 0.32 -5.9u 0.328 0.59u 0.336 -2.7u 0.344 -3.02u 0.352 -8.3u 0.36 -29.9u 0.368 -33.6u 0.376 -23.0u 0.384 -24.1u 0.392 -23.0u 0.4 -24.1u)" savecurrent=false}
C {res.sym} 360 -530 3 0 {name=R15
value=50k
footprint=1206
device=resistor
m=1}
C {vsource.sym} 110 -510 1 0 {name=Vinn7 value="1.0" savecurrent=false}
C {gnd.sym} 80 -510 1 0 {name=l12 lab=GND}
C {res.sym} 220 -510 3 0 {name=R16
value=50k
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} 410 -690 3 0 {name=p11 sig_type=std_logic lab=Vin3n}
C {lab_pin.sym} 420 -510 3 0 {name=p12 sig_type=std_logic lab=Vin4n}
C {gnd.sym} 1630 -230 1 0 {name=l4 lab=GND}
C {vsource.sym} 1540 -250 1 0 {name=VDD value="DC 3.3" savecurrent=false}
C {gnd.sym} 1510 -250 1 0 {name=l5 lab=GND}
C {res.sym} 1600 -250 3 0 {name=R3
value=150m
footprint=1206
device=resistor
m=1}
C {vsource.sym} 1380 -210 1 0 {name=Vclkin value="PULSE(0 3.3 0 10n 10n 0.5m 1m)" savecurrent=false}
C {gnd.sym} 1350 -210 1 0 {name=l6 lab=GND}
C {res.sym} 1440 -210 3 0 {name=R4
value=50
footprint=1206
device=resistor
m=1}
C {gnd.sym} 1630 -500 1 0 {name=l7 lab=GND}
C {vsource.sym} 1540 -520 1 0 {name=VDD1 value="DC 3.3" savecurrent=false}
C {gnd.sym} 1510 -520 1 0 {name=l13 lab=GND}
C {res.sym} 1600 -520 3 0 {name=R5
value=150m
footprint=1206
device=resistor
m=1}
C {vsource.sym} 1380 -480 1 0 {name=Vclkin1 value="PULSE(0 3.3 0 10n 10n 125u 250u)" savecurrent=false}
C {gnd.sym} 1350 -480 1 0 {name=l14 lab=GND}
C {res.sym} 1440 -480 3 0 {name=R6
value=50
footprint=1206
device=resistor
m=1}
C {gnd.sym} 1630 -370 1 0 {name=l15 lab=GND}
C {vsource.sym} 1540 -390 1 0 {name=VDD2 value="DC 3.3" savecurrent=false}
C {gnd.sym} 1510 -390 1 0 {name=l16 lab=GND}
C {res.sym} 1600 -390 3 0 {name=R8
value=150m
footprint=1206
device=resistor
m=1}
C {vsource.sym} 1380 -350 1 0 {name=Vclkin2 value="PULSE(0 3.3 0 10n 10n 250u 500u)" savecurrent=false}
C {gnd.sym} 1350 -350 1 0 {name=l17 lab=GND}
C {res.sym} 1440 -350 3 0 {name=R9
value=50
footprint=1206
device=resistor
m=1}
C {noconn.sym} 1840 -520 0 0 {name=l18}
C {noconn.sym} 1840 -500 0 0 {name=l19}
C {noconn.sym} 1840 -390 0 0 {name=l20}
C {noconn.sym} 1840 -370 0 0 {name=l21}
C {noconn.sym} 1840 -250 0 0 {name=l22}
C {noconn.sym} 1840 -230 0 0 {name=l23}
C {lab_pin.sym} 1830 -520 1 0 {name=p1 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} 1830 -500 3 0 {name=p2 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 1830 -390 1 0 {name=p3 sig_type=std_logic lab=_CLKB}
C {lab_pin.sym} 1830 -370 3 0 {name=p4 sig_type=std_logic lab=CLKB}
C {lab_pin.sym} 1820 -250 1 0 {name=p13 sig_type=std_logic lab=_CLKC}
C {lab_pin.sym} 1820 -230 3 0 {name=p14 sig_type=std_logic lab=CLKC}
C {noconn.sym} 480 -1160 0 0 {name=l24}
C {noconn.sym} 520 -1160 0 0 {name=l25}
C {noconn.sym} 480 -970 0 0 {name=l26}
C {noconn.sym} 520 -970 0 0 {name=l27}
C {noconn.sym} 480 -780 0 0 {name=l28}
C {noconn.sym} 520 -780 0 0 {name=l29}
C {noconn.sym} 480 -600 0 0 {name=l30}
C {noconn.sym} 520 -600 0 0 {name=l31}
C {noconn.sym} 490 -620 0 0 {name=l32}
C {noconn.sym} 490 -440 0 0 {name=l34}
C {noconn.sym} 490 -980 0 0 {name=l36}
C {noconn.sym} 780 -1140 0 0 {name=l38}
C {noconn.sym} 820 -1140 0 0 {name=l39}
C {noconn.sym} 780 -860 0 0 {name=l40}
C {noconn.sym} 780 -830 0 0 {name=l42}
C {noconn.sym} 820 -830 0 0 {name=l43}
C {noconn.sym} 780 -540 0 0 {name=l44}
C {noconn.sym} 1080 -640 0 0 {name=l46}
C {noconn.sym} 1080 -1090 0 0 {name=l48}
C {noconn.sym} 1120 -1090 0 0 {name=l49}
C {lab_pin.sym} 520 -1150 1 0 {name=p15 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} 520 -950 1 0 {name=p16 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} 520 -770 1 0 {name=p17 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} 520 -590 1 0 {name=p18 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} 480 -1150 1 0 {name=p19 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 480 -950 1 0 {name=p20 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 480 -770 1 0 {name=p21 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 480 -590 1 0 {name=p22 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 780 -1130 1 0 {name=p23 sig_type=std_logic lab=_CLKB}
C {lab_pin.sym} 780 -810 1 0 {name=p24 sig_type=std_logic lab=_CLKB}
C {lab_pin.sym} 820 -1130 1 0 {name=p25 sig_type=std_logic lab=CLKB}
C {lab_pin.sym} 820 -820 1 0 {name=p26 sig_type=std_logic lab=CLKB}
C {lab_pin.sym} 1080 -1070 1 0 {name=p27 sig_type=std_logic lab=_CLKC}
C {lab_pin.sym} 1120 -1060 1 0 {name=p28 sig_type=std_logic lab=CLKC}
C {gnd.sym} 1120 -690 0 0 {name=l41 lab=GND}
C {gnd.sym} 820 -880 0 0 {name=l47 lab=GND}
C {gnd.sym} 820 -570 0 0 {name=l45 lab=GND}
C {noconn.sym} 490 -800 0 0 {name=l33}
C {gnd.sym} 520 -1000 0 0 {name=l35 lab=GND}
C {gnd.sym} 520 -820 0 0 {name=l37 lab=GND}
C {gnd.sym} 520 -640 0 0 {name=l50 lab=GND}
C {gnd.sym} 520 -460 0 0 {name=l51 lab=GND}
C {lab_pin.sym} 1080 -660 2 0 {name=p29 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 780 -870 2 0 {name=p30 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 780 -550 2 0 {name=p31 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 490 -440 2 0 {name=p32 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 490 -630 2 0 {name=p33 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 490 -810 2 0 {name=p34 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 490 -990 2 0 {name=p35 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1640 -520 1 0 {name=p36 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 610 -1050 2 0 {name=p37 sig_type=std_logic lab=Vout1pA}
C {lab_pin.sym} 620 -1070 2 0 {name=p46 sig_type=std_logic lab=Vout1nA}
C {lab_pin.sym} 600 -870 2 0 {name=p47 sig_type=std_logic lab=Vout2pA}
C {lab_pin.sym} 620 -890 2 0 {name=p48 sig_type=std_logic lab=Vout2nA}
C {lab_pin.sym} 920 -1030 2 0 {name=p53 sig_type=std_logic lab=Vout1pB}
C {lab_pin.sym} 930 -980 2 0 {name=p54 sig_type=std_logic lab=Vout1nB}
C {lab_pin.sym} 920 -910 2 0 {name=p55 sig_type=std_logic lab=Vout2pB}
C {lab_pin.sym} 880 -880 2 0 {name=p56 sig_type=std_logic lab=Vout2nB}
C {noconn.sym} 2450 -1150 0 0 {name=l68}
C {noconn.sym} 2490 -1150 0 0 {name=l69}
C {noconn.sym} 2450 -960 0 0 {name=l70}
C {noconn.sym} 2490 -960 0 0 {name=l71}
C {noconn.sym} 2450 -770 0 0 {name=l72}
C {noconn.sym} 2490 -770 0 0 {name=l73}
C {noconn.sym} 2450 -590 0 0 {name=l74}
C {noconn.sym} 2490 -590 0 0 {name=l75}
C {noconn.sym} 2460 -610 0 0 {name=l76}
C {noconn.sym} 2460 -430 0 0 {name=l77}
C {noconn.sym} 2460 -970 0 0 {name=l78}
C {noconn.sym} 2150 -1120 0 0 {name=l79}
C {noconn.sym} 2190 -1120 0 0 {name=l80}
C {noconn.sym} 2150 -840 0 0 {name=l81}
C {noconn.sym} 2150 -810 0 0 {name=l82}
C {noconn.sym} 2190 -810 0 0 {name=l83}
C {noconn.sym} 2150 -520 0 0 {name=l84}
C {noconn.sym} 1800 -650 0 0 {name=l85}
C {noconn.sym} 1800 -1100 0 0 {name=l86}
C {noconn.sym} 1840 -1100 0 0 {name=l87}
C {lab_pin.sym} 2450 -1140 1 0 {name=p61 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} 2450 -950 1 0 {name=p62 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} 2450 -760 1 0 {name=p63 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} 2450 -580 1 0 {name=p64 sig_type=std_logic lab=_CLKA}
C {lab_pin.sym} 2490 -1140 1 0 {name=p65 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 2490 -940 1 0 {name=p66 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 2490 -760 1 0 {name=p67 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 2490 -580 1 0 {name=p68 sig_type=std_logic lab=CLKA}
C {lab_pin.sym} 2150 -1110 1 0 {name=p69 sig_type=std_logic lab=_CLKB}
C {lab_pin.sym} 2150 -790 1 0 {name=p70 sig_type=std_logic lab=_CLKB}
C {lab_pin.sym} 2190 -1110 1 0 {name=p71 sig_type=std_logic lab=CLKB}
C {lab_pin.sym} 2190 -800 1 0 {name=p72 sig_type=std_logic lab=CLKB}
C {lab_pin.sym} 1800 -1080 1 0 {name=p73 sig_type=std_logic lab=_CLKC}
C {lab_pin.sym} 1840 -1070 1 0 {name=p74 sig_type=std_logic lab=CLKC}
C {gnd.sym} 1840 -700 0 0 {name=l88 lab=GND}
C {gnd.sym} 2190 -860 0 0 {name=l89 lab=GND}
C {gnd.sym} 2190 -550 0 0 {name=l90 lab=GND}
C {noconn.sym} 2460 -790 0 0 {name=l91}
C {gnd.sym} 2490 -990 0 0 {name=l92 lab=GND}
C {gnd.sym} 2490 -810 0 0 {name=l93 lab=GND}
C {gnd.sym} 2490 -630 0 0 {name=l94 lab=GND}
C {gnd.sym} 2490 -450 0 0 {name=l95 lab=GND}
C {lab_pin.sym} 1800 -670 2 0 {name=p75 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2150 -850 2 0 {name=p76 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2150 -530 2 0 {name=p77 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2460 -440 2 0 {name=p78 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2460 -620 2 0 {name=p79 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2460 -800 2 0 {name=p80 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 2460 -980 2 0 {name=p81 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 890 -850 2 0 {name=p38 sig_type=std_logic lab=Vout3pB}
C {lab_pin.sym} 930 -720 2 0 {name=p39 sig_type=std_logic lab=Vout4pB}
C {lab_pin.sym} 910 -790 2 0 {name=p40 sig_type=std_logic lab=Vout3nB}
C {lab_pin.sym} 960 -640 2 0 {name=p41 sig_type=std_logic lab=Vout4nB}
C {devices/code_shown.sym} 3070 -1010 0 0 {name=NGSPICE only_toplevel=true
value="
.tran 100u 0.4 0 100u
.options method=gear
.options plotwinsize=0
.control
run
plot v(OUTCH1PFIN)-V(OUTCH1NFIN) v(OUTCH2PFIN)-V(OUTCH2NFIN) v(OUTCH3PFIN)-V(OUTCH3NFIN) v(OUTCH4PFIN)-V(OUTCH4NFIN)
*plot v(Vout1pA)-v(Vout1nA)
*plot v(Vout1pC)-v(Vout1nC)
*plot v(Vout1pC2)-v(Vout1nC2)
*plot v(Vout1pB)-v(Vout1nB)
*plot v(Vout1pB2)-v(Vout1nB2)
*plot v(Vout1pA2)-v(Vout1nA2)
*plot v(Vout1nB)-v(Vout2nB)
*plot v(Vout2pA)-v(Vout2nA)
*plot v(Vout1p)-v(Vout1n)
*plot v(Vout2p)-v(Vout2n)
*plot v(Vout3p)-v(Vout3n)
*plot v(Vout4p)-v(Vout4n)
.endc
"}
C {vsource.sym} 1110 -500 1 0 {name=V19 value="1.5" savecurrent=false}
C {gnd.sym} 1050 -500 1 0 {name=l53 lab=GND}
C {vsource.sym} 1110 -450 1 0 {name=V20 value="3.3" savecurrent=false}
C {gnd.sym} 1050 -450 1 0 {name=l54 lab=GND}
C {res.sym} 1180 -450 3 0 {name=R10
value=150m
footprint=1206
device=resistor
m=1}
C {res.sym} 1180 -500 3 0 {name=R11
value=150m
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} 1230 -450 2 0 {name=p106 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1230 -500 2 0 {name=p107 sig_type=std_logic lab=VBIAS}
C {vsource.sym} 1110 -570 1 0 {name=V2 value="1" savecurrent=false}
C {gnd.sym} 1050 -570 1 0 {name=l56 lab=GND}
C {res.sym} 1210 -570 3 0 {name=R17
value=150m
footprint=1206
device=resistor
m=1}
C {lab_pin.sym} 1260 -570 2 0 {name=p108 sig_type=std_logic lab=VCM}
C {lab_pin.sym} 1990 -1010 2 0 {name=p44 sig_type=std_logic lab=Vout1pB2}
C {lab_pin.sym} 2000 -960 2 0 {name=p45 sig_type=std_logic lab=Vout1nB2}
C {lab_pin.sym} 2290 -1060 2 0 {name=p52 sig_type=std_logic lab=Vout1pA2}
C {lab_pin.sym} 2320 -1010 2 0 {name=p57 sig_type=std_logic lab=Vout1nA2}
C {noconn.sym} 1440 -1050 2 0 {name=l52}
C {lab_pin.sym} 1440 -1030 0 0 {name=p42 sig_type=std_logic lab=VDD}
C {noconn.sym} 1460 -1050 2 0 {name=l55}
C {lab_pin.sym} 1460 -1030 2 0 {name=p43 sig_type=std_logic lab=VBIAS}
C {noconn.sym} 1440 -680 0 0 {name=l57}
C {lab_pin.sym} 1440 -700 0 0 {name=p49 sig_type=std_logic lab=VCM}
C {gnd.sym} 1460 -680 0 0 {name=l58 lab=GND}
C {noconn.sym} 2210 -370 1 0 {name=l59}
C {lab_pin.sym} 2220 -370 1 0 {name=p50 sig_type=std_logic lab=VDD}
C {gnd.sym} 2220 -350 1 0 {name=l60 lab=GND}
C {noconn.sym} 2950 -1020 1 0 {name=l61}
C {lab_pin.sym} 2940 -1020 2 0 {name=p51 sig_type=std_logic lab=OUTCH1PFIN}
C {noconn.sym} 2950 -1000 1 0 {name=l62}
C {lab_pin.sym} 2940 -1000 2 0 {name=p58 sig_type=std_logic lab=OUTCH1NFIN}
C {noconn.sym} 2950 -840 1 0 {name=l63}
C {lab_pin.sym} 2940 -840 2 0 {name=p59 sig_type=std_logic lab=OUTCH2PFIN}
C {noconn.sym} 2950 -820 1 0 {name=l64}
C {lab_pin.sym} 2940 -820 2 0 {name=p60 sig_type=std_logic lab=OUTCH2NFIN}
C {noconn.sym} 2950 -660 1 0 {name=l65}
C {lab_pin.sym} 2940 -660 2 0 {name=p90 sig_type=std_logic lab=OUTCH3PFIN}
C {noconn.sym} 2950 -640 1 0 {name=l66}
C {lab_pin.sym} 2940 -640 2 0 {name=p91 sig_type=std_logic lab=OUTCH3NFIN}
C {noconn.sym} 2950 -480 1 0 {name=l67}
C {lab_pin.sym} 2940 -480 2 0 {name=p92 sig_type=std_logic lab=OUTCH4PFIN}
C {noconn.sym} 2950 -460 1 0 {name=l96}
C {lab_pin.sym} 2940 -460 2 0 {name=p93 sig_type=std_logic lab=OUTCH4NFIN}
C {noconn.sym} 2780 -1140 2 0 {name=l97}
C {lab_pin.sym} 2780 -1120 0 0 {name=p82 sig_type=std_logic lab=VDD}
C {noconn.sym} 2730 -910 1 0 {name=l98}
C {lab_pin.sym} 2750 -910 3 0 {name=p83 sig_type=std_logic lab=VDD}
C {noconn.sym} 2730 -730 1 0 {name=l99}
C {lab_pin.sym} 2750 -730 3 0 {name=p84 sig_type=std_logic lab=VDD}
C {noconn.sym} 2730 -550 1 0 {name=l100}
C {lab_pin.sym} 2750 -550 3 0 {name=p85 sig_type=std_logic lab=VDD}
C {gnd.sym} 2800 -550 2 0 {name=l101 lab=GND}
C {gnd.sym} 2800 -730 2 0 {name=l102 lab=GND}
C {gnd.sym} 2800 -910 2 0 {name=l103 lab=GND}
C {gnd.sym} 2800 -1090 3 0 {name=l104 lab=GND}
C {devices/code_shown.sym} 3364.998521357774 -851.6202324628828 0 0 {name=MODELS1 only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
* .lib $::180MCU_MODELS/sm141064.ngspice res_statistical
"}
C {xschem top/Chopper Switch/switch_A.sym} 400 -1000 0 0 {name=x1}
C {xschem top/Chopper Switch/switch_A.sym} 400 -820 0 0 {name=x2}
C {xschem top/Chopper Switch/switch_A.sym} 400 -640 0 0 {name=x3}
C {xschem top/Chopper Switch/switch_A.sym} 400 -460 0 0 {name=x4}
C {xschem top/Chopper Switch/switch_B.sym} 860 -570 0 0 {name=x5}
C {xschem top/Chopper Switch/switch_B.sym} 860 -880 0 0 {name=x6}
C {xschem top/Chopper Switch/switch_C.sym} 1100 -910 0 0 {name=x7}
C {xschem top/Chopper Switch/switch_C.sym} 1820 -920 0 0 {name=x11}
C {xschem top/Chopper Switch/switch_B.sym} 2230 -860 0 0 {name=x12}
C {xschem top/Chopper Switch/switch_B.sym} 2230 -550 0 0 {name=x13}
C {xschem top/Chopper Switch/switch_A.sym} 2370 -990 0 0 {name=x14}
C {xschem top/Chopper Switch/switch_A.sym} 2370 -810 0 0 {name=x15}
C {xschem top/Chopper Switch/switch_A.sym} 2370 -630 0 0 {name=x16}
C {xschem top/Chopper Switch/Complementary CLK for Switches/clk.sym} 1810 -500 0 0 {name=x24}
C {xschem top/Chopper Switch/Complementary CLK for Switches/clk.sym} 1810 -370 0 0 {name=x8}
C {xschem top/Chopper Switch/Complementary CLK for Switches/clk.sym} 1810 -230 0 0 {name=x9}
C {xschem top/LPF/Complementary CLK for LPF/clk_lpf.sym} 2370 -350 0 0 {name=x18}
C {xschem top/LPF/lpf.sym} 2860 -470 0 0 {name=x19}
C {xschem top/LPF/lpf.sym} 2860 -650 0 0 {name=x20}
C {xschem top/LPF/lpf.sym} 2860 -830 0 0 {name=x21}
C {xschem top/LPF/lpf.sym} 2860 -1010 0 0 {name=x22}
C {xschem top/Chopper Switch/switch_A.sym} 2370 -450 0 0 {name=x17}
C {xschem top/INA/FULL_INA_TB.sym} 1210 -410 0 0 {name=x10}
