** sch_path: ISSCC25/submitted_notebooks/sch/inverter.sch
**.subckt inverter
M1 VOUT VIN VDD DMP2035U m=1
M2 VOUT VIN GND M2N7002 m=1
**.ends
.GLOBAL GND
.end
