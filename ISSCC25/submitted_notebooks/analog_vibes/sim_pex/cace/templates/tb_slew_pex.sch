** sch_path: ISSCC25/submitted_notebooks/analog_vibes/sim_pex/cace/templates/tb_slew_pex.sch
**.subckt tb_slew_pex
V0 AVSS GND 0
V1 AVDD AVSS CACE{AVDD}
I1 AVDD IBIAS1_10U CACE{IB}
C1 VOUT AVSS CACE{C_LOAD} m=1
E1 INP IPCM DIFFIN AVSS 0.5
E3 INM IPCM DIFFIN AVSS -0.5
V4 IPCM AVSS 0.9
V5 DIFFIN AVSS pulse(-1.8 1.8 50us 100ns 100ns 50us 100us)
I2 AVDD IBIAS2_10U CACE{IB}
x1 AVDD AVSS INP INM IBIAS1_10U IBIAS2_10U VOUT ota_pex
**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}

.control
tran 10n 150u
let rise_slew = maximum(deriv(v(VOUT)))
let fall_slew = minimum(deriv(v(VOUT)))*-1
echo $&rise_slew $&fall_slew > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc


.temp CACE{temperature}

**** end user architecture code
**.ends

* expanding   symbol:
*+  /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/xschem/ota_pex.sym # of pins=7
** sym_path: ISSCC25/submitted_notebooks/analog_vibes/sim_pex/xschem/ota_pex.sym
.include /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/xschem/ota_pex.spice
.GLOBAL GND
.end
