** sch_path: /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/runs/RUN_2024-12-01_16-10-40/parameters/psrr_params/run_18/tb_psrr_pex.sch
**.subckt tb_psrr_pex
V0 AVSS GND 0
V1 AVDD AVSS dc 1.7 ac 1
I1 AVDD IBIAS1_10U 9.999999999999999e-06
V2 IPCM AVSS 1.2
V3 VIN IPCM 0
C1 VOUT AVSS 8e-11 m=1
I2 AVDD IBIAS2_10U 9.999999999999999e-06
x1 AVDD AVSS VIN VOUT IBIAS1_10U IBIAS2_10U VOUT ota_pex
**** begin user architecture code

.param mc_mm_switch=0
.param mc_pr_switch=0
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/corners/ss.spice
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical.spice
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical__lin.spice
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/corners/ss/specialized_cells.spice

.control
ac dec 20 1 1e12
let out_db = db(abs(v(VOUT)))
meas ac PSRR_DC find out_db at=1
echo $&PSRR_DC > /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/runs/RUN_2024-12-01_16-10-40/parameters/psrr_params/run_18/tb_psrr_pex_18.data
quit

.endc

.temp 27

**** end user architecture code
**.ends

* expanding   symbol:  xschem/ota_pex.sym # of pins=7
** sym_path: /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/xschem/ota_pex.sym
.include ./ota_pex.spice
.GLOBAL GND
.end
