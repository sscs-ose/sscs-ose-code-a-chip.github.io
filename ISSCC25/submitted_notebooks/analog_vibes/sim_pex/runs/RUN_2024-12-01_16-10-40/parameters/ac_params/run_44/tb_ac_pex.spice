** sch_path: /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/runs/RUN_2024-12-01_16-10-40/parameters/ac_params/run_44/tb_ac_pex.sch
**.subckt tb_ac_pex
V0 AVSS GND 0
V1 AVDD AVSS 1.9
I1 AVDD IBIAS1_10U 9.999999999999999e-06
E1 INP IPCM DIFFIN AVSS 0.5
E3 INM IPCM DIFFIN AVSS -0.5
V2 IPCM AVSS 1.2
V3 DIFFIN AVSS dc 0 ac 1
C1 VOUT AVSS 8e-11 m=1
I2 AVDD IBIAS2_10U 9.999999999999999e-06
x1 AVDD AVSS INP INM IBIAS1_10U IBIAS2_10U VOUT ota_pex
**** begin user architecture code

.param mc_mm_switch=0
.param mc_pr_switch=0
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/corners/fs.spice
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical.spice
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical__lin.spice
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/corners/fs/specialized_cells.spice

.control
ac dec 20 1 1e12
let out_db = db(abs(v(VOUT)))
let out_pm = phase(v(VOUT))*180/pi + 180
meas ac A0 find out_db at=1
meas ac UGF when out_db=0 fall=1
meas ac PM find out_pm when out_db=0

echo $&A0 $&UGF $&PM > /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/runs/RUN_2024-12-01_16-10-40/parameters/ac_params/run_44/tb_ac_pex_44.data
quit

.endc

.temp 125

**** end user architecture code
**.ends

* expanding   symbol:  xschem/ota_pex.sym # of pins=7
** sym_path: /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/xschem/ota_pex.sym
.include ./ota_pex.spice
.GLOBAL GND
.end
