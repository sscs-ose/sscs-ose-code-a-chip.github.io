** sch_path: /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/runs/RUN_2024-12-01_16-14-17/parameters/noise_params/run_43/tb_noise_pex.sch
**.subckt tb_noise_pex
V0 AVSS GND 0
V1 AVDD AVSS 1.8
I1 AVDD IBIAS1_10U 9.999999999999999e-06
V2 IPCM AVSS 1.2
V3 VIN IPCM dc 0 ac 1
C1 VOUT AVSS 8e-11 m=1
I2 AVDD IBIAS2_10U 9.999999999999999e-06
x1 AVSS AVDD VOUT VIN VOUT IBIAS2_10U IBIAS1_10U ota_pex
**** begin user architecture code

.param mc_mm_switch=0
.param mc_pr_switch=0
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/corners/fs.spice
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical.spice
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical__lin.spice
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/corners/fs/specialized_cells.spice

.control
noise v(VOUT) V3 dec 20 1000 1e6
let vin_noi_rms = inoise_total*1e6
echo $&vin_noi_rms > /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/runs/RUN_2024-12-01_16-14-17/parameters/noise_params/run_43/tb_noise_pex_43.data
quit

.endc

.temp 125

**** end user architecture code
**.ends

* expanding   symbol:  xschem/ota_pex.sym # of pins=7
** sym_path: /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/xschem/ota_pex.sym
.include /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/xschem/ota_pex.spice
.GLOBAL GND
.end
