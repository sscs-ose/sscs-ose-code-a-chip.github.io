** sch_path: /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/runs/RUN_2024-12-01_16-14-17/parameters/cmrr_params/run_08/tb_cmrr_pex.sch
**.subckt tb_cmrr_pex
V0 AVSS GND 0
V1 AVDD AVSS 1.9
I1 AVDD IBIAS1_10U 9.999999999999999e-06
E1 INP IPCM DIFFIN AVSS 0.5
E3 INM IPCM DIFFIN AVSS -0.5
V2 IPCM AVSS dc 1.2 ac 1
V3 DIFFIN AVSS dc
C1 VOUT AVSS 8e-11 m=1
I2 AVDD IBIAS2_10U 9.999999999999999e-06
x1 AVSS AVDD INM INP VOUT IBIAS2_10U IBIAS1_10U ota_pex
**** begin user architecture code

.param mc_mm_switch=0
.param mc_pr_switch=0
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/corners/ff.spice
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical.spice
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical__lin.spice
.include /home/sscspico/miniconda3/share/pdk/sky130A/libs.tech/ngspice/corners/ff/specialized_cells.spice

.control
ac dec 20 1 1e12
let out_db = db(abs(v(VOUT)))
meas ac CMRR_DC find out_db at=1
echo $&CMRR_DC > /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/runs/RUN_2024-12-01_16-14-17/parameters/cmrr_params/run_08/tb_cmrr_pex_8.data
quit

.endc

.temp -40

**** end user architecture code
**.ends

* expanding   symbol:  xschem/ota_pex.sym # of pins=7
** sym_path: /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/xschem/ota_pex.sym
.include /home/sscspico/test_tools/coc_analog_vibes/ISSCC25/submitted_notebooks/analog_vibes/sim_pex/xschem/ota_pex.spice
.GLOBAL GND
.end
