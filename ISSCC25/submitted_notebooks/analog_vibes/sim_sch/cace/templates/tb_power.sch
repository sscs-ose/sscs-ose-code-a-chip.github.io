** sch_path: ISSCC25/submitted_notebooks/analog_vibes/sim_sch/cace/templates/tb_power.sch
**.subckt tb_power
V0 AVSS GND 0
V1 AVDD AVSS CACE{AVDD}
I1 AVDD IBIAS1_10U CACE{IB}
E1 INP IPCM DIFFIN AVSS 0.5
E3 INM IPCM DIFFIN AVSS -0.5
V2 IPCM AVSS CACE{IPCM}
V3 DIFFIN AVSS 0
C1 VOUT AVSS CACE{C_LOAD} m=1
I2 AVDD IBIAS2_10U CACE{IB}
x1 AVDD AVSS INP INM IBIAS1_10U IBIAS2_10U VOUT ota
**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}

.control
op
save all
save @m.x1.xm1.msky130_fd_pr__pfet_01v8_lvt[id]
save @m.x1.xm2.msky130_fd_pr__pfet_01v8_lvt[id]
save @m.x1.xm9.msky130_fd_pr__pfet_01v8_lvt[id]
save @m.x1.xm10.msky130_fd_pr__pfet_01v8_lvt[id]
save @m.x1.xm14.msky130_fd_pr__pfet_01v8_lvt[id]
save @m.x1.xm12.msky130_fd_pr__pfet_01v8_lvt[id]

let power_ota_core = CACE{AVDD}*(@m.x1.xm1.msky130_fd_pr__pfet_01v8_lvt[id] + @m.x1.xm2.msky130_fd_pr__pfet_01v8_lvt[id]
+ + @m.x1.xm9.msky130_fd_pr__pfet_01v8_lvt[id] + @m.x1.xm10.msky130_fd_pr__pfet_01v8_lvt[id] + @m.x1.xm14.msky130_fd_pr__pfet_01v8_lvt[id]
+ + @m.x1.xm12.msky130_fd_pr__pfet_01v8_lvt[id])
let power_tot = -1*CACE{AVDD}*i(V1)
let power_ota_bias = power_tot-power_ota_core
echo $&power_tot $&power_ota_core $&power_ota_bias > CACE{simpath}/CACE{filename}_CACE{N}.data
quit

.endc


.temp CACE{temperature}

**** end user architecture code
**.ends
.GLOBAL GND
.end
