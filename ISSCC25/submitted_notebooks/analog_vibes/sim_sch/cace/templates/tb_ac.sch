** sch_path: ISSCC25/submitted_notebooks/analog_vibes/sim_sch/cace/templates/tb_ac.sch
**.subckt tb_ac
V0 AVSS GND 0
V1 AVDD AVSS CACE{AVDD}
I1 AVDD IBIAS1_10U CACE{IB}
E1 INP IPCM DIFFIN AVSS 0.5
E3 INM IPCM DIFFIN AVSS -0.5
V2 IPCM AVSS CACE{IPCM}
V3 DIFFIN AVSS dc 0 ac 1
C1 VOUT AVSS CACE{C_LOAD} m=1
I2 AVDD IBIAS2_10U CACE{IB}
x1 AVDD AVSS INP INM IBIAS1_10U IBIAS2_10U VOUT ota
**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}

.control
ac dec 20 1 1e12
let out_db = db(abs(v(VOUT)))
let out_pm = phase(v(VOUT))*180/pi + 180
meas ac A0 find out_db at=1
meas ac UGF when out_db=0 fall=1
meas ac PM find out_pm when out_db=0

echo $&A0 $&UGF $&PM > CACE{simpath}/CACE{filename}_CACE{N}.data
quit

.endc


.temp CACE{temperature}

**** end user architecture code
**.ends
.GLOBAL GND
.end
