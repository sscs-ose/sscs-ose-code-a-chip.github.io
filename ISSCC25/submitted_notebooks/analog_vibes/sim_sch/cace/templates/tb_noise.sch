** sch_path: ISSCC25/submitted_notebooks/analog_vibes/sim_sch/cace/templates/tb_noise.sch
**.subckt tb_noise
V0 AVSS GND 0
V1 AVDD AVSS CACE{AVDD}
I1 AVDD IBIAS1_10U CACE{IB}
V2 IPCM AVSS CACE{IPCM}
V3 VIN IPCM dc 0 ac 1
C1 VOUT AVSS CACE{C_LOAD} m=1
I2 AVDD IBIAS2_10U CACE{IB}
x1 AVDD AVSS VIN VOUT IBIAS1_10U IBIAS2_10U VOUT ota
**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}

.control
noise v(VOUT) V3 dec 20 1000 1e6
let vin_noi_rms = inoise_total*1e6
echo $&vin_noi_rms > CACE{simpath}/CACE{filename}_CACE{N}.data
quit

.endc


.temp CACE{temperature}

**** end user architecture code
**.ends
.GLOBAL GND
.end
