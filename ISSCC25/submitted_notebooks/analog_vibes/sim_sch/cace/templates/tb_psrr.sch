** sch_path: ISSCC25/submitted_notebooks/analog_vibes/sim_sch/cace/templates/tb_psrr.sch
**.subckt tb_psrr
V0 AVSS GND 0
V1 AVDD AVSS dc CACE{AVDD} ac 1
I1 AVDD IBIAS1_10U CACE{IB}
V2 IPCM AVSS CACE{IPCM}
V3 VIN IPCM 0
C1 VOUT AVSS CACE{C_LOAD} m=1
I2 AVDD IBIAS2_10U CACE{IB}
x1 AVDD AVSS VIN VOUT IBIAS1_10U IBIAS2_10U VOUT ota
**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}

.control
ac dec 20 1 1e12
let out_db = db(abs(v(VOUT)))
meas ac PSRR_DC find out_db at=1
echo $&PSRR_DC > CACE{simpath}/CACE{filename}_CACE{N}.data
quit

.endc


.temp CACE{temperature}

**** end user architecture code
**.ends
.GLOBAL GND
.end
